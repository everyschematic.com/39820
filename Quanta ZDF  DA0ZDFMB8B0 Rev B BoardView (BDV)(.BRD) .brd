# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DA7219_HPL: length 5.9
  TOP w0.203: 10.82,29.51 U6504.A3
  TOP w0.508: v1(10.02,28.71) 10.82,29.51
  IN1 w0.508: v1(10.02,28.71) 10.02,28.45 11.29,27.18 v1(13.69,27.18)
DA7219_HPR: length 8.9
  TOP w0.203: v1(10.12,30.71) 10.78,30.05 U6504.A5
  IN1 w0.203: v1(6.71,35.19) 6.66,35.14 6.66,31.25 7.04,30.87 9.63,30.87 9.76,30.74 10.09,30.74 v1(10.12,30.71)
DA7219_INT_ODL: length 147.2
  TOP w0.089: v2(38.69,35.36) 37.77,36.29 30.44,36.29 29.98,36.75 26.68,36.75 23.37,40.05 20.45,40.05 19.12,41.39 17.98,41.39 17.45,40.85 17.45,37.7 15.71,35.96 15.71,35.26 15.55,35.11 v1(15.55,34.78) ; v1(14.49,33.05) 13.44,33.05 12.96,32.57 12.96,31.97 12.39,31.4 U6504.D10 ; v2(95.89,37.02) 95.89,36.43 R90561.2 95.27,35.8 93.88,35.8 93.47,36.21 92.77,36.21 92.39,35.83 v1(92.24,35.83)
  IN1 w0.06: v1(92.24,35.83) 91.92,35.83 91.47,36.28 90.32,36.28 v7(90.24,36.36)
  IN1 w0.076: v1(15.55,34.78) 15.65,34.68 15.65,33.43 15.54,33.32 15.08,33.32 14.87,33.12 14.55,33.12 v1(14.49,33.05)
  IN2 w0.058: v2(95.89,37.02) 96.05,37.02 96.25,37.22 97.42,37.22 98.15,36.48 98.15,36.38 98.48,36.05 98.48,35.37 97.78,34.66 97.78,32.07 97.87,31.98 97.87,30.26 98.57,29.57 98.57,28.48 99.09,27.96 99.09,27.06 99.87,26.28 100.67,26.28 101.41,25.54 v3(101.41,25.15) ; v2(38.69,35.36) 38.69,35.03 38.92,34.8 40.01,34.8 40.29,35.08 v3(40.29,35.13)
  IN3 w0.102: v3(101.41,25.15) 101.41,24.75 101.05,24.39 100.91,24.39 98.05,21.54 92.43,21.54 91.26,20.37 87.91,20.37 87,19.46 78.2,19.46 70.49,27.16 70.49,27.9 69.92,28.48 66.63,28.48 66.51,28.61 66.51,33.79 65.77,34.52 63.66,34.52 61.5,32.37 61.5,29.98 61.86,29.62 61.86,29.01 61.4,28.56 61.29,28.56 59.08,26.35 49.39,26.35 46.5,29.23 45.29,29.23 43.66,30.86 41.62,30.86 40.62,31.86 40.62,34.75 40.27,35.11 40.27,35.11 v3(40.29,35.13)
DA7219_MIC: length 2.6
  TOP w0.203: R90332.1 11.84,35.22 U6504.C15
DA7219_MIC_N: length 7.1
  TOP w0.254: U6504.A15 10.93,32.75 9.89,33.79 v2(9.89,33.92)
  IN2 w0.254: v2(8.48,29.22) 8.48,29.33 9.44,30.3 9.44,33.47 v2(9.89,33.92)
DA7219_MIC_P: length 7.7
  TOP w0.254: U6504.B16 11.2,33.31 11,33.31 v2(10.52,33.79)
  IN2 w0.254: v2(8.48,28.2) 9.13,28.84 9.13,29.34 9.89,30.11 9.89,33.15 v2(10.52,33.79)
DA7219_MICBIAS: length 4.5
  TOP w0.203: R90332.2 11.8,36.08 11.02,35.3 C9055.2 10.9,34.17 v1(11.29,33.79)
  IN1 w0.203: v1(11.5,32.48) 11.16,32.82 11.16,33.66 v1(11.29,33.79)
DA7219_VDD:
  vias: v1(11.84,30.05) v1(12.76,30.13) v1(13.06,30.13)
DA7219_VDD_MIC: length 3.4
  TOP w0.203: U6504.A13 10.78,32.21
  TOP w0.381: R90529.2 9.26,34 C9057.1 9.56,33.41 10.76,32.21 10.78,32.21
DA7219_VDDIO: length 1.3
  TOP w0.203: U6504.D4 12.37,29.78 12.6,29.55
  TOP w0.381: 13.23,29.11 12.79,29.55 12.6,29.55
DA7219_VMID: length 2.4
  TOP w0.089: U6504.A9 10.78,31.5 10.53,31.5 9.64,32.39 C9051.1
DA7219_VREF: length 2.4
  TOP w0.089: C9050.1 9.95,31.04 10.78,31.04 11.16,30.66 U6504.A7
DEBUG_SPI_FLASH_CS_L: length 36
  TOP w0.089: v2(58.15,18.65) 57.9,18.41 U124.J7
  IN2 w0.058: v2(58.15,18.65) 57.72,19.08 57.37,19.08 57.03,19.42 57.03,19.92 55.82,21.13 54.37,21.13 54.03,20.78 52.19,20.78 50.67,22.3 48.93,22.3 47.99,23.25 v2(47.99,23.32) 47.79,23.12 47.79,22.84 47.53,22.59 47.53,21.8 47.64,21.69 47.64,17.44 44.46,14.26 44.46,12.43 44.84,12.05 44.84,8.34 46.85,6.33 46.91,6.33 46.97,6.27 v3(46.97,6.25)
  IN4 w0.058: v5(47.23,4.98) 47.23,5.06 47.1,5.19 47.1,6.15 47.02,6.23 47,6.23 v3(46.97,6.25)
  BOTTOM w0.089: v5(47.23,4.98) 47.23,4.91 47.3,4.84 CON16.3
DEBUG_SPI_FLASH_HOLD_L: length 14.9
  TOP w0.089: U49.7 47.1,14.62 v2(47.48,14.24)
  IN2 w0.058: v3(46.92,7.17) 46.88,7.21 46.88,12.44 47.18,12.73 47.18,13.9 47.33,14.05 47.33,14.09 v2(47.48,14.24)
  IN4 w0.058: v5(48.24,5.41) 48.04,5.61 48.04,6.43 47.3,7.17 v3(46.92,7.17)
  BOTTOM w0.089: v5(48.24,5.41) 46.9,5.41 46.5,5.01 CON16.7
DEBUG_SPI_FLASH_MISO: length 35.7
  IN2 w0.058: v2(57.48,19.41) 57.48,19.77 55.91,21.34 54.29,21.34 53.94,20.99 52.28,20.99 50.76,22.52 50.45,22.52 49.31,23.65 47.05,23.65 v2(46.74,23.35) 46.69,23.29 46.69,22.21 47.43,21.47 47.43,17.53 44.18,14.28 44.18,12.33 44.62,11.88 44.62,8.24 46.46,6.4 46.46,5.9 v3(46.59,5.77)
  IN4 w0.058: v5(46.85,4.78) 46.71,4.92 46.71,5.61 46.59,5.72 v3(46.59,5.77)
  BOTTOM w0.089: CON16.5 46.9,4.37 46.87,4.4 46.87,4.68 46.85,4.71 v5(46.85,4.78)
DEBUG_SPI_FLASH_MOSI: length 27.1
  IN2 w0.058: v2(54.98,19.41) 54.98,19.53 54.92,19.59 54.92,20.07 55.13,20.27 55.13,20.55 54.97,20.71 54.55,20.71 54.2,20.36 52.02,20.36 50.5,21.88 49.07,21.88 48.52,21.33 48.52,17.09 46.9,15.47 46.9,14.21 46.62,13.93 46.62,13.47 46.44,13.29 46.01,13.29 45.7,13.6 v2(45.04,13.6) 44.92,13.47 44.92,12.6 45.75,11.77 45.75,9.45 v3(45.91,9.3)
  IN4 w0.058: v5(47.3,9.15) 46.84,8.69 46.19,8.69 45.91,8.97 v3(45.91,9.3)
  BOTTOM w0.089: v5(47.3,9.15) CON16.4
DEBUG_SPI_FLASH_SCK: length 29.6
  IN2 w0.058: v2(56.48,19.41) 56.48,20.17 55.74,20.92 54.46,20.92 54.11,20.57 52.11,20.57 50.58,22.09 48.98,22.09 48.31,21.42 48.31,17.18 46.67,15.54 46.67,14.28 46.31,13.92 v2(46.31,13.6) 46.01,13.6 45.68,13.93 44.89,13.93 44.69,13.72 44.69,12.5 45.06,12.13 45.06,9.59 45.22,9.43 v3(45.22,9.35)
  IN4 w0.058: v3(45.22,9.35) 45.22,9.18 45.96,8.44 47.05,8.44 v5(47.73,9.12)
  BOTTOM w0.089: v5(47.73,9.12) 47.73,9.02 47.79,8.97 CON16.2
DIOM4_NC: length 2.4
  TOP w0.089: R90377.2 51.93,15.5 52.69,16.26 53.34,16.26 U124.A3
DISP_PWM: length 63.9
  TOP w0.089: v1(44.07,39.55) 44.04,39.53 Q706.1 ; U1001.AH23 89.36,33.09 89.36,32.43 89.39,32.4 89.39,32.31 v2(89.44,32.26)
  IN1 w0.076: v1(44.07,39.55) 46.3,41.79 47.33,41.79 47.51,41.61 47.51,41.23 47.76,40.98 50.02,40.98 51.11,39.88 51.54,39.88 54.87,36.56 54.87,36.3 56.12,35.06 57.26,35.06 57.89,34.42 59.72,34.42 59.83,34.32 60.61,34.32 60.82,34.12 61.43,34.12 61.8,33.74 61.93,33.74 64.33,31.35 69.12,31.35 69.53,31.76 72.17,31.76 73.44,30.49 73.44,29.01 75.67,26.78 76.89,26.78 79.82,23.86 83.47,23.86 83.83,24.21 85.61,24.21 85.71,24.11 86.42,24.11 86.72,24.42 86.72,25.25 87.61,26.14 87.61,27.54 87.69,27.62 87.69,28.23 87.82,28.35 v2(88.1,28.35)
  IN2 w0.058: v2(88.1,28.35) 88.12,28.38 88.15,28.38 88.17,28.4 88.51,28.4 89.35,29.25 89.35,32.1 89.42,32.16 89.42,32.24 v2(89.44,32.26)
DMIC_CLK: length 140.9
  TOP w0.089: U2001.K1 107.96,35.32 v2(108.14,35.32)
  IN2 w0.058: v2(108.14,35.32) 108.29,35.48 109.57,35.48 109.66,35.38 109.66,34.14 109.99,33.81 109.99,32.98 110.38,32.6 112.32,32.6 112.92,31.99 113.86,31.99 114.54,31.31 v3(114.54,31.13) ; v3(37.6,36.43) 37.5,36.53 37.5,41.11 37.71,41.33 38.05,41.33 v3(38.44,41.71)
  IN3 w0.102: v3(114.54,31.13) 114.87,31.46 114.87,32.21 114.71,32.37 114.71,33.94 114.87,34.09 114.87,34.27 115.12,34.52 115.12,38.62 117.86,41.37 117.86,44.33 117.81,44.38 117.81,47.11 116.75,48.18 116.75,48.69 115.71,49.73 115.71,50.79 116.47,51.55 116.47,54.33 114.23,56.56 114.23,58.37 110.72,61.88 95.95,61.88 95.16,61.08 79.1,61.08 78.52,60.51 76.97,60.51 v3(75.66,59.2)
  IN4 w0.058: v5(75.32,59.04) 75.48,59.2 v3(75.66,59.2) ; v5(38.02,42.69) 38.1,42.69 38.34,42.45 38.34,41.81 v3(38.44,41.71) ; v3(37.6,36.43) 37.37,36.43 37.19,36.25 v5(37.05,36.25)
  BOTTOM w0.089: v5(75.32,59.04) 75.29,59.01 74.47,59.01 72.51,57.05 72.51,51.91 72.06,51.47 71.4,51.47 70.11,50.18 69.34,50.18 68.9,49.74 67.32,49.74 66.02,48.44 59.48,48.44 59.11,48.8 47.1,48.8 46.46,48.16 46.46,43.12 45.86,42.51 38.38,42.51 38.2,42.69 v5(38.02,42.69)
DMIC_DATA_1: length 140.2
  IN2 w0.058: v3(37.8,41.71) 37.19,41.1 37.19,36.07 36.48,35.36 v3(36.48,34.7) ; v3(114.41,32.01) 114.41,32.14 114.35,32.2 113.01,32.2 112.41,32.81 110.54,32.81 110.2,33.14 110.2,33.93 109.87,34.26 109.87,35.48 109.74,35.61 108.09,35.61 v8(108.07,35.63)
  IN3 w0.102: v3(75.65,58.58) 75.78,58.58 76.13,58.93 76.13,59.31 77.07,60.25 78.63,60.25 79.2,60.83 95.26,60.83 96.06,61.63 110.61,61.63 113.98,58.26 113.98,56.46 116.21,54.22 116.21,51.66 115.45,50.89 115.45,49.62 116.49,48.58 116.49,48.07 117.56,47.01 117.56,44.11 117.61,44.06 117.61,41.47 114.87,38.73 114.87,34.63 114.61,34.37 114.61,34.22 114.46,34.07 114.46,32.06 v3(114.41,32.01)
  IN4 w0.058: v3(37.8,41.71) 37.8,42.07 v5(38.01,42.27) ; v3(36.48,34.7) 36.7,34.92 v5(36.81,34.92) ; v3(75.65,58.58) v5(75.27,58.58)
  BOTTOM w0.089: R102.1 37.25,34.61 36.95,34.92 v5(36.81,34.92) ; v5(75.27,58.58) 75.08,58.77 74.57,58.77 72.75,56.95 72.75,51.81 72.16,51.23 71.5,51.23 70.21,49.94 69.44,49.94 68.98,49.49 67.41,49.49 66.12,48.2 59.38,48.2 59.01,48.56 47.2,48.56 46.71,48.06 46.71,43.02 45.96,42.27 v5(38.01,42.27)
DMIC_DATA_1_R: length 1.8
  BOTTOM w0.089: R102.2 36.47,35.1 36.55,35.18 J15.6
DP_AUX_N: length 11.6
  TOP w0.071: C9036.2 20.84,25.74 20.77,25.67 20.22,25.67 20.15,25.74 v2(20.15,25.91) ; v2(16.39,29.47) 16.44,29.52 17.43,29.52 17.56,29.4 U93.13
  IN2 w0.056: v2(16.39,29.47) 16.59,29.47 16.79,29.27 17.03,29.27 17.18,29.11 v3(17.18,29.01) ; v3(17.69,25.91) 17.94,25.66 18.71,25.66 18.81,25.56 19.85,25.56 20.15,25.86 v2(20.15,25.91)
  IN3 w0.089: v3(17.18,29.01) 16.99,29.2 16.75,29.2 16.59,29.04 16.59,28.26 17.2,27.64 17.2,25.84 17.29,25.75 17.52,25.75 v3(17.69,25.91)
DP_AUX_P: length 11.7
  TOP w0.071: U93.12 16.83,29.8 v2(16.77,29.85) ; C9035.2 20.84,25.38 20.77,25.45 20.24,25.45 20.15,25.35 v2(20.15,25.15)
  IN2 w0.056: v3(17.66,25.3) 17.81,25.46 18.63,25.46 18.73,25.36 19.94,25.36 v2(20.15,25.15) ; v3(17.18,29.62) 17.03,29.47 16.88,29.47 16.77,29.58 v2(16.77,29.85)
  IN3 w0.089: v3(17.66,25.3) 17.46,25.51 17.19,25.51 16.96,25.74 16.96,27.54 16.35,28.16 16.35,29.14 16.65,29.44 17,29.44 v3(17.18,29.62)
DP_LN0_N: length 10.3
  TOP w0.071: U93.17 18.9,26.88 18.86,26.84 18.67,26.84 18.44,26.61 v2(18.44,26.51)
  IN2 w0.056: v2(18.44,26.51) 18.5,26.57 18.5,26.85 18.37,26.98 v3(18.25,26.98) ; v2(18.49,21.44) 18.49,21.17 18.4,21.09 18.25,21.09 18.07,21.27 17.79,21.27 17.71,21.34 v3(17.71,21.52)
  IN3 w0.089: v3(18.25,26.98) 18.49,26.74 18.49,26.59 18.32,26.42 18.32,24.9 17.52,24.1 17.52,22.37 18.18,21.71 18.18,21.42 18.07,21.3 17.93,21.3 v3(17.71,21.52)
DP_LN0_P: length 10.3
  TOP w0.071: v2(18.85,26.51) 19.3,26.97 U93.18
  IN2 w0.056: v3(18.86,27.01) 18.85,27 v2(18.85,26.51) ; v3(17.71,20.88) 17.89,21.06 17.98,21.06 18.16,20.88 18.4,20.88 18.49,20.79 v2(18.49,20.43)
  IN3 w0.089: v3(17.71,20.88) 17.89,21.06 18.17,21.06 18.42,21.32 18.42,21.81 17.76,22.47 17.76,24 18.56,24.8 18.56,26.32 18.73,26.49 18.73,26.88 v3(18.86,27.01)
DP_LN1_N: length 12.6
  TOP w0.071: v2(19.59,26.66) 19.59,26.68 19.7,26.79 U93.19
  IN2 w0.056: v3(18.86,28.17) 19.08,27.95 19.08,27.61 19.74,26.95 19.74,26.82 v2(19.59,26.66) ; v3(19.16,22.32) 19.16,22.21 19.29,22.08 19.66,22.08 19.89,21.85 20.07,21.85 20.2,21.98 v2(20.2,22.23)
  IN3 w0.089: v3(18.86,28.17) 19.04,27.99 19.04,27.75 19.58,27.21 19.58,26.37 19.03,25.82 19.03,24.64 18.32,23.93 18.32,23.27 18.8,22.79 19.35,22.79 19.63,22.51 19.63,22.27 19.49,22.13 19.35,22.13 v3(19.16,22.32)
DP_LN1_P: length 12.6
  TOP w0.071: v2(20.07,26.64) 20.07,26.65 20.1,26.68 U93.20
  IN2 w0.056: v3(19.46,28.16) 19.29,27.98 19.29,27.69 19.95,27.03 19.95,26.77 v2(20.07,26.64) ; v3(19.16,21.71) 19.33,21.88 19.58,21.88 19.8,21.65 20.03,21.65 v2(20.2,21.47)
  IN3 w0.089: v3(19.46,28.16) 19.28,27.98 19.28,27.85 19.82,27.31 19.82,26.27 19.27,25.72 19.27,24.54 18.56,23.83 18.56,23.37 18.9,23.03 19.45,23.03 19.87,22.61 19.87,22.17 19.59,21.89 19.34,21.89 v3(19.16,21.71)
DP_LN2_N: length 13.6
  TOP w0.071: U93.21 20.5,26.96 20.72,26.74 v2(20.72,26.65)
  IN2 w0.056: v3(20.38,28.05) 20.51,27.92 20.51,27.56 20.79,27.28 20.79,26.72 v2(20.72,26.65) ; v2(21.35,23.37) 21.35,23.29 21.45,23.2 21.62,23.2 21.78,23.35 v3(21.78,23.4)
  IN3 w0.089: v3(20.38,28.05) 20.48,27.95 20.48,27.46 20.65,27.3 20.65,26.19 19.66,25.2 19.66,23.35 20.67,22.33 20.85,22.33 21.31,21.87 22.05,21.87 22.46,22.28 22.46,22.97 22.23,23.2 21.92,23.2 21.78,23.34 v3(21.78,23.4)
DP_LN2_P: length 13.6
  TOP w0.071: U93.22 20.9,26.91 21.14,26.68 v2(21.14,26.65)
  IN2 w0.056: v3(21.75,22.59) 21.75,22.91 21.67,22.99 21.43,22.99 21.35,22.91 v2(21.35,22.61) ; v3(21.17,28.05) 20.9,28.05 20.71,27.85 20.71,27.64 20.99,27.36 20.99,26.8 v2(21.14,26.65)
  IN3 w0.089: v3(21.17,28.05) 21.04,28.05 20.72,27.73 20.72,27.56 20.89,27.4 20.89,26.09 19.9,25.1 19.9,23.45 20.77,22.57 20.95,22.57 21.41,22.11 21.95,22.11 22.22,22.38 22.22,22.87 22.13,22.95 21.87,22.95 21.75,22.84 v3(21.75,22.59)
DP_LN3_N: length 9.7
  TOP w0.071: v2(22.36,26.63) 22.36,26.65 22.25,26.76 22.16,26.76 22.01,26.62 21.65,26.62 21.3,26.97 U93.23
  IN2 w0.056: v3(20.61,24.39) 20.58,24.36 20.58,24.21 20.46,24.09 20,24.09 19.67,23.76 19.57,23.76 19.41,23.92 v2(19.41,24.14) ; v3(22.84,26.5) 22.84,26.65 22.76,26.73 22.46,26.73 v2(22.36,26.63)
  IN3 w0.089: v3(22.84,26.5) 23.03,26.69 23.21,26.69 23.3,26.6 23.3,26.24 23.08,26.03 22.11,26.03 21.5,25.42 21.5,24.66 20.92,24.09 20.65,24.09 20.56,24.17 20.56,24.34 v3(20.61,24.39)
DP_LN3_P: length 9.7
  TOP w0.071: U93.24 21.7,26.88 21.75,26.84 21.92,26.84 22.06,26.99 22.29,26.99 v2(22.36,27.06)
  IN2 w0.056: v3(20.61,23.63) 20.58,23.65 20.58,23.78 20.48,23.88 20.08,23.88 19.75,23.55 19.57,23.55 19.41,23.39 v2(19.41,23.12) ; v2(22.36,27.06) 22.49,26.93 22.66,26.93 v3(22.84,27.11)
  IN3 w0.089: v3(22.84,27.11) 23.02,26.93 23.31,26.93 23.54,26.7 23.54,26.14 23.18,25.79 22.21,25.79 21.74,25.32 21.74,24.56 21.02,23.84 20.77,23.84 20.61,23.68 v3(20.61,23.63)
DPI_CK: length 77.9
  IN1 w0.06: v7(90.24,35.16) 90.13,35.16 89.93,35.36 89.74,35.36 89.64,35.25 89.64,34.67 89.49,34.52 v2(89.49,33.92)
  IN2 w0.058: v2(89.49,33.92) 89.72,33.69 89.72,32.62 89.94,32.4 89.94,31.68 89.93,31.67 89.93,28.23 89.37,27.68 89.37,25.78 89.14,25.55 89.14,24.92 87.23,23.01 84.84,23.01 84.68,22.86 78.8,22.86 72.4,29.26 72.4,30.07 71.24,31.23 67.18,31.23 66.14,30.18 63.89,30.18 63.43,30.64 62.98,30.64 62.54,30.21 61.37,30.21 60.46,29.29 60.46,29.02 60.02,28.58 60.02,27.82 59.69,27.49 49.73,27.49 47.61,29.62 44.82,29.62 42.52,27.32 42.52,26.92 40.2,24.6 40.2,22.97 39.94,22.71 39.55,22.71 39.27,22.99 38.73,22.99 38.49,22.75 38.49,22.31 39.05,21.75 39.05,21.47 39.23,21.29 39.56,21.29 v3(39.63,21.22) 39.35,20.94 v2(39.31,20.94)
  IN4 w0.058: v5(39.15,21.14) 39.56,21.14 v3(39.63,21.22)
DPI_D0: length 81
  IN1 w0.06: v7(89.44,36.76) 89.52,36.76 89.72,36.56 89.93,36.56 90.04,36.45 90.04,36.28 90.15,36.16 91.14,36.16 91.6,35.7 91.6,35.03 v2(92.24,34.4)
  IN2 w0.058: v2(92.24,34.4) 92.08,34.4 91.85,34.17 91.79,34.17 91.65,34.03 91.65,32.37 91,31.72 91,27.81 90.43,27.24 90.43,25.34 90.2,25.11 90.2,24.42 87.73,21.95 86.53,21.95 86.18,21.59 85.12,21.59 84.91,21.8 78.31,21.8 71.32,28.8 71.32,28.94 70.08,30.17 67.62,30.17 66.58,29.13 63.12,29.13 62.42,28.43 61.61,28.43 61.07,27.89 61.07,27.36 60.1,26.39 49.34,26.39 47.17,28.56 45.25,28.56 43.57,26.88 43.57,26.31 41.29,24.04 41.29,21.15 40.95,20.81 40.29,20.81 40.09,20.61 39.71,20.61 v3(39.57,20.47) 39.39,20.29 v2(39.29,20.29)
  IN4 w0.058: v5(37.88,20.25) 38.65,20.25 38.72,20.18 39.06,20.18 39.34,20.47 v3(39.57,20.47)
DPI_D1: length 80
  IN1 w0.06: v7(90.24,35.96) 90.62,35.96 91.25,35.33 91.25,35.16 92.02,34.38 92.02,34.31 92.32,34.01 v2(92.34,34.01)
  IN2 w0.058: v2(39.96,20.29) 40.25,20.29 40.32,20.35 40.45,20.35 v3(40.5,20.4) 40.85,20.4 41.5,21.05 41.5,23.92 43.78,26.2 43.78,26.79 45.34,28.35 47.08,28.35 49.25,26.18 60.19,26.18 61.28,27.28 61.28,27.81 61.7,28.22 62.51,28.22 63.21,28.92 66.67,28.92 67.71,29.96 70,29.96 71.11,28.85 71.11,28.71 78.22,21.59 84.82,21.59 85.03,21.38 86.26,21.38 86.62,21.74 87.81,21.74 90.41,24.33 90.41,25.02 90.64,25.25 90.64,27.15 91.21,27.73 91.21,31.59 91.93,32.31 91.93,33.48 92.18,33.74 92.18,33.86 v2(92.34,34.01)
  IN4 w0.058: v3(40.5,20.4) 40.45,20.35 40.06,20.35 39.84,20.13 39.2,20.13 39.12,20.05 38.67,20.05 38.64,20.07 38.34,20.07 38.21,19.95 v5(38.21,19.92)
  BOTTOM w0.089: v5(38.21,19.92) 38.18,19.92 37.85,19.59 R90821.1
DPI_D2: length 77.5
  IN1 w0.06: v7(90.24,36.76) 90.29,36.76 90.53,36.52 92.14,36.52 92.6,36.06 92.6,35.28 93.07,34.8 93.07,34.55
  IN1 w0.076: 93.07,34.55 93.07,33.79 v2(92.77,33.48)
  IN2 w0.058: v2(39.24,19.64) 39.4,19.64 v3(39.56,19.79) 39.56,19.59 39.81,19.34 40.06,19.34 40.27,19.54 40.65,19.54 41.93,20.82 41.93,23.71 43.98,25.76 60.37,25.76 61.54,26.93 66.25,26.93 66.75,26.44 72.78,26.44 78.05,21.17 84.64,21.17 84.85,20.96 86.44,20.96 86.79,21.31 87.99,21.31 90.83,24.16 90.83,24.85 91.06,25.08 91.06,26.98 91.64,27.55 91.64,31.33 92.39,32.09 92.39,33.23 92.62,33.46 92.74,33.46 v2(92.77,33.48)
  IN4 w0.058: v5(39.08,19.78) 39.11,19.81 39.54,19.81 v3(39.56,19.79)
  BOTTOM w0.089: R90820.1 39.12,19.82 v5(39.08,19.78)
DPI_D3: length 79
  TOP w0.089: v2(93.23,33.53) 93.23,33.61 93.45,33.84 93.45,34.4 92.46,35.39 92.34,35.39 91.98,35.75 91.98,35.82 91.27,36.53 90.87,36.53 U1001.W26
  IN2 w0.058: v2(39.96,19.64) v3(40.19,19.87) 40.61,19.87 41.72,20.97 41.72,23.8 43.89,25.97 60.28,25.97 61.5,27.19 61.5,27.72 61.78,28.01 62.59,28.01 63.29,28.71 66.75,28.71 67.79,29.75 69.91,29.75 70.88,28.78 70.88,28.64 78.13,21.38 84.73,21.38 84.94,21.17 86.35,21.17 86.7,21.52 87.9,21.52 90.62,24.24 90.62,24.94 90.85,25.17 90.85,27.06 91.43,27.64 91.43,31.5 92.16,32.24 92.16,33.33 92.64,33.81 92.9,33.81 93.12,33.58 93.18,33.58 v2(93.23,33.53)
  IN4 w0.058: v3(40.19,19.87) 39.77,19.44 39.1,19.44 v5(39.02,19.36)
DPI_D4: length 74.8
  TOP w0.06: U1001.AB26 90.69,35.56 90.94,35.31 91.42,35.31
  TOP w0.089: 91.42,35.31 92.13,34.6 92.13,33.66 92.71,33.09 v2(92.71,33.06)
  IN2 w0.058: v2(92.71,33.06) 92.71,32.05 91.89,31.23 91.89,27.5 91.27,26.89 91.27,24.99 91.04,24.76 91.04,24.07 88.08,21.1 86.88,21.1 86.53,20.75 84.77,20.75 84.56,20.96 77.96,20.96 72.69,26.23 66.55,26.23 66.06,26.72 61.62,26.72 60.45,25.55 44.1,25.55 42.14,23.59 42.14,20.74 40.59,19.18 v3(40.39,19.18) 40.2,18.98 v2(39.96,18.98)
  IN4 w0.058: v3(40.39,19.18) 39.96,18.75 39.03,18.75 38.97,18.69 v5(38.97,18.68)
DPI_D5: length 77
  IN1 w0.06: 91.93,32.42 91.93,33.77 91.42,34.28 91.42,34.47 90.89,35.01 90.89,35.16 90.69,35.36 90.11,35.36 90.04,35.44 90.04,35.68 89.96,35.76 89.63,35.76 v7(89.43,35.56)
  IN1 w0.076: v2(92.36,31.25) 92.26,31.35 92.26,32.09 91.93,32.42
  IN2 w0.058: v2(39.23,18.98) 39.4,18.98 v3(39.53,19.11) 39.53,18.98 39.81,18.7 40.52,18.7 42.36,20.53 42.36,23.48 44.21,25.34 60.54,25.34 61.71,26.51 65.97,26.51 66.46,26.01 72.61,26.01 77.87,20.75 84.47,20.75 84.68,20.54 86.61,20.54 86.97,20.89 88.16,20.89 91.25,23.98 91.25,24.67 91.48,24.9 91.48,26.8 92.12,27.44 92.12,31.01 v2(92.36,31.25)
  IN4 w0.058: v3(39.53,19.11) 37.95,19.11 v5(37.91,19.06)
DPI_D6: length 78.8
  IN1 w0.06: 92.39,33.48 92.82,33.92 92.82,34.89 92.48,35.23 92.48,36.01 92.09,36.4 90.48,36.4 90.32,36.56 90.13,36.56 89.93,36.76 v7(89.83,36.76)
  IN1 w0.076: 92.39,33.48 92.39,32.94 93.15,32.17 93.15,30.66 v2(92.95,30.46)
  IN2 w0.058: v2(92.95,30.46) 92.54,30.46 92.33,30.25 92.33,27.35 91.69,26.72 91.69,24.82 91.46,24.59 91.46,23.89 88.25,20.68 87.05,20.68 86.7,20.33 84.59,20.33 84.38,20.54 77.7,20.54 72.44,25.8 66.38,25.8 65.88,26.3 61.8,26.3 60.63,25.13 44.3,25.13 42.58,23.41 42.58,20.38 40.47,18.27 v3(40.39,18.27) 40.1,18.27 v2(40.04,18.33)
  IN4 w0.058: v5(39.4,18.01) 40.14,18.01 v3(40.39,18.27)
  BOTTOM w0.089: v5(39.4,18.01) 39.69,18.3 R90824.1
DPI_D7: length 78.6
  IN1 w0.06: v7(89.83,36.36) 89.83,36.31 90.04,36.11 90.04,35.87 90.14,35.76 90.64,35.76 91.13,35.28 91.13,35.11 91.9,34.33 91.9,34.14 92.24,33.81 92.24,32.92
  IN1 w0.076: 92.24,32.92 92.24,32.76 92.92,32.08 92.92,30.99 92.59,30.66 92.59,30.23 v2(92.69,30.13)
  IN2 w0.058: v2(92.69,30.13) 92.54,29.98 92.54,27.27 91.9,26.63 91.9,24.73 91.67,24.5 91.67,23.81 88.34,20.47 87.14,20.47 86.79,20.12 84.5,20.12 84.29,20.33 77.61,20.33 72.35,25.59 66.29,25.59 65.79,26.09 61.89,26.09 60.72,24.92 44.41,24.92 42.81,23.31 42.81,20.07 40.65,17.91 40.09,17.91 v3(39.61,18.4) 39.3,18.4 v2(39.28,18.37)
  IN4 w0.058: v5(37.88,18.07) 37.88,18.14 38.18,18.45 39.56,18.45 v3(39.61,18.4)
DPI_D8: length 79.8
  IN2 w0.058: v2(39.96,17.69) 40.06,17.58 v3(40.47,17.58) 40.85,17.58 43.03,19.76 43.03,23.22 44.51,24.71 60.8,24.71 61.97,25.88 65.71,25.88 66.2,25.38 72.22,25.38 77.48,20.12 84.21,20.12 84.42,19.91 86.88,19.91 87.23,20.26 88.44,20.26 91.89,23.71 91.89,24.41 92.12,24.64 92.12,26.54 92.75,27.18 92.75,29.49 92.93,29.67 92.93,29.9 93.07,30.05 93.07,30.15 93.28,30.36 93.28,30.56 92.95,30.89 92.95,32.8 93.55,33.4 93.55,33.77 93.45,33.86 93.16,33.86 92.37,34.65 92.07,34.65 91.81,34.91 91.14,34.91 90.36,35.69 89.97,35.69 v8(89.83,35.56)
  IN4 w0.058: v5(40.14,17.66) 40.39,17.66 v3(40.47,17.58)
  BOTTOM w0.089: R90830.1 38.08,17.43 38.26,17.61 40.09,17.61 v5(40.14,17.66)
DPI_D9: length 78
  TOP w0.089: U1001.Y26 90.65,36.37 91.19,36.37 91.81,35.75 91.81,35.69 92.74,34.75 92.74,33.66 93.25,33.15 93.25,30.31 v2(93.46,30.1)
  IN2 w0.058: v2(93.46,30.1) 93.43,30.1 93.15,29.83 93.15,29.55 92.96,29.36 92.96,27.09 92.33,26.45 92.33,24.55 92.1,24.32 92.1,23.62 88.53,20.05 87.32,20.05 86.96,19.7 84.33,19.7 84.12,19.91 77.39,19.91 72.13,25.17 66.11,25.17 65.62,25.67 62.06,25.67 60.89,24.49 44.6,24.49 43.24,23.14 43.24,19.67 40.8,17.23 40.27,17.23 40.19,17.3 39.72,17.3 v3(39.62,17.4) 39.34,17.69 v2(39.31,17.69)
  IN4 w0.058: v5(39.23,17.1) 39.32,17.1 v3(39.62,17.4)
DPI_D10: length 77.4
  TOP w0.075: U1001.AA26 90.9,36.22 91.11,36.22 91.25,36.08
  TOP w0.089: v2(93.48,29.7) 93.48,29.7 93.3,29.7 93,30 93,33.15 92.57,33.58 92.57,34.55 91.65,35.47 91.65,35.68 91.25,36.08
  IN2 w0.058: v2(39.96,17.04) 40.06,17.04 v3(40.25,16.85) 40.73,16.85 43.46,19.58 43.46,23.05 44.69,24.28 60.98,24.28 62.15,25.45 65.53,25.45 66.03,24.96 72.04,24.96 77.31,19.7 84.03,19.7 84.24,19.49 87.05,19.49 87.4,19.84 88.61,19.84 92.31,23.53 92.31,24.24 92.54,24.47 92.54,26.37 93.18,27 93.18,29.17 93.48,29.47 v2(93.48,29.7)
  IN4 w0.058: v5(40.16,16.49) 40.16,16.77 v3(40.25,16.85)
DPI_D11: length 85.2
  IN2 w0.058: v8(89.39,36) 89.55,36.17 90.06,36.17 91.2,35.02 91.86,35.02 92.12,34.76 92.55,34.76 93.23,34.09 93.53,34.09 93.79,33.84 93.79,33.33 93.16,32.7 93.16,30.98 93.79,30.35 93.79,29.42 93.4,29.04 93.4,26.93 92.75,26.28 92.75,24.38 92.52,24.15 92.52,23.44 88.7,19.63 87.49,19.63 87.14,19.28 84.15,19.28 83.94,19.49 77.22,19.49 71.95,24.75 65.94,24.75 65.44,25.24 62.23,25.24 61.06,24.07 61.06,23.44 60.39,22.77 58.08,22.77 57.97,22.88 55.67,22.88 55.32,23.24 55.32,23.78 55.03,24.07 44.78,24.07 43.67,22.96 43.67,19.49 40.65,16.47 39.88,16.47 v3(39.54,16.8) v2(39.31,17.04)
  IN4 w0.058: v5(37.3,16.29) 37.8,15.78 39.23,15.78 39.48,16.03 39.48,16.74 v3(39.54,16.8)
DPI_DE: length 76.4
  IN2 w0.058: v2(39.96,20.94) 40.24,21.22 v3(40.47,21.22) 41.08,21.82 41.08,24.15 43.36,26.43 43.36,26.97 45.16,28.77 47.26,28.77 49.43,26.6 60.02,26.6 60.86,27.45 60.86,27.98 61.52,28.64 62.33,28.64 63.03,29.34 66.49,29.34 67.53,30.38 70.17,30.38 71.53,29.03 71.53,28.88 78.4,22.02 84.99,22.02 85.2,21.81 86.09,21.81 86.44,22.16 87.64,22.16 89.99,24.51 89.99,25.2 90.22,25.43 90.22,27.33 90.79,27.9 90.79,33.27 90.66,33.41 90.66,35.08 v2(90.64,35.11)
  IN4 w0.058: v3(40.47,21.22) 40.27,21.22 39.91,20.86 38.79,20.86 38.74,20.81 38.57,20.81 38.41,20.96 38.41,21.04 38.24,21.22 v5(37.93,21.22)
DPI_HSYNC: length 76.2
  TOP w0.089: U5.B6 40.32,21.94 v2(40.32,21.95)
  IN2 w0.058: v3(39.75,22.1) 39.93,21.92 40.27,21.92 40.29,21.95 v2(40.32,21.95) 40.33,21.94 40.41,21.94 40.64,22.17 40.64,24.33 42.94,26.63 42.94,27.14 44.99,29.19 47.43,29.19 49.6,27.02 59.84,27.02 60.44,27.62 60.44,28.16 61.35,29.06 62.16,29.06 62.86,29.76 66.32,29.76 67.36,30.8 70.35,30.8 71.97,29.18 71.97,29.08 78.61,22.44 85.17,22.44 85.38,22.23 85.91,22.23 86.27,22.58 87.47,22.58 89.57,24.68 89.57,25.37 89.8,25.6 89.8,27.5 90.37,28.08 90.37,33.06 90.28,33.15 90.28,34.55 89.46,35.37 89.31,35.37 89.14,35.53 89.14,36.2 89.31,36.36 v8(89.41,36.36)
  IN4 w0.058: v5(39.07,22.74) 39.25,22.74 39.75,22.24 v3(39.75,22.1)
DPI_VSYNC: length 75.8
  IN2 w0.058: v8(89.83,35.96) 89.63,35.76 89.63,35.45 90.53,34.55 90.53,33.15 90.58,33.1 90.58,27.99 90.01,27.41 90.01,25.52 89.78,25.29 89.78,24.59 87.55,22.37 86.35,22.37 86,22.02 85.29,22.02 85.08,22.23 78.48,22.23 71.74,28.97 71.74,29.11 70.26,30.59 67.44,30.59 66.4,29.55 62.94,29.55 62.24,28.85 61.44,28.85 60.65,28.07 60.65,27.54 59.93,26.81 49.52,26.81 47.35,28.98 45.08,28.98 43.15,27.06 43.15,26.54 40.85,24.24 40.85,22.03 40.45,21.62 39.43,21.62 v2(39.38,21.67) 39.33,21.72 39.33,22.08 v3(39.15,22.26)
  IN4 w0.058: v3(39.15,22.26) 39.15,21.9 v5(39.1,21.85)
DSI0_CKN: length 69.7
  IN2 w0.056: v2(69.37,42.63) 69.2,42.8 69.2,42.93 69.25,42.98 69.48,42.98 69.73,42.73 70.03,42.73 70.21,42.9 70.21,43.38 70.26,43.44 70.37,43.44 70.43,43.38 70.43,42.98 70.61,42.81 70.89,42.81 71.06,42.98 71.06,43.28 71.12,43.34 71.23,43.34 71.28,43.28 71.28,42.95 71.43,42.81 72.16,42.81 72.22,42.74 72.22,42.66 72.09,42.53 71.71,42.53 71.53,42.35 71.53,41.94 71.7,41.78 71.97,41.78 72.02,41.73 72.02,41.5 71.81,41.29 71.81,40.51 71.98,40.34 72.53,40.34 72.7,40.52 72.7,42.22 73.13,42.65 73.13,43.31 72.96,43.49 72.08,43.49 71.99,43.58 71.99,43.69 v3(72.42,44.13) ; v8(89.84,37.56) 89.93,37.56 90.13,37.76 90.74,37.76 v3(90.86,37.88)
  IN3 w0.089: v3(72.42,44.13) 72.22,43.92 72.22,43.75 72.32,43.66 72.82,43.66 73.13,43.34 73.36,43.34 74.77,41.94 74.77,32.9 75.01,32.65 75.01,30.38 75.76,29.63 76.16,29.63 76.82,28.97 76.82,28.22 80.45,24.59 83.11,24.59 83.77,25.25 89.2,25.25 90.39,26.45 94.2,26.45 95.91,28.16 95.91,34.2 94.57,35.55 94.57,36.35 94.29,36.62 92.25,36.62 91.91,36.96 91.46,36.96 91.08,37.33 91.08,37.66 v3(90.86,37.88)
DSI0_CKP: length 69.7
  IN2 w0.056: v3(71.79,44.15) 71.79,43.49 71.99,43.29 72.87,43.29 72.93,43.23 72.93,42.74 72.5,42.31 72.5,40.6 72.44,40.55 72.07,40.55 72.02,40.6 72.02,41.2 72.22,41.41 72.22,41.81 72.06,41.98 71.78,41.98 71.74,42.03 71.74,42.26 71.8,42.32 72.17,42.32 72.43,42.58 72.43,42.83 72.25,43.01 71.52,43.01 71.49,43.04 71.49,43.37 71.31,43.54 71.03,43.54 70.86,43.37 70.86,43.06 70.8,43.01 70.69,43.01 70.63,43.06 70.63,43.47 70.46,43.64 70.18,43.64 70,43.47 70,42.99 69.95,42.93 69.82,42.93 69.56,43.19 69.52,43.19 v2(69.37,43.34) ; v8(90.24,37.56) 90.24,37.55 90.81,37.55 90.83,37.54 91.12,37.54 91.25,37.66 91.25,37.73 91.38,37.87 v3(91.44,37.87)
  IN3 w0.089: v3(91.44,37.87) 91.42,37.87 91.33,37.78 91.33,37.43 91.56,37.2 92.01,37.2 92.35,36.87 94.39,36.87 94.81,36.45 94.81,35.65 96.15,34.3 96.15,28.06 94.3,26.21 90.49,26.21 89.3,25.01 83.87,25.01 83.21,24.35 80.35,24.35 76.58,28.12 76.58,28.87 76.06,29.39 75.66,29.39 74.77,30.28 74.77,32.55 74.53,32.8 74.53,41.84 73.26,43.1 73.03,43.1 72.72,43.41 72.22,43.41 71.98,43.65 71.98,43.96 v3(71.79,44.15)
DSI0_D0N: length 68.4
  TOP w0.071: v1(92.36,38.24) 92.34,38.24 92.24,38.14 91.93,38.14 91.78,38.29 91.1,38.29 U1001.R27
  IN1 w0.069: v2(92.46,37.94) 92.36,38.04 v1(92.36,38.24)
  IN2 w0.056: v2(69.37,44.18) 69.22,44.33 69.22,44.48 69.29,44.55 69.62,44.55 69.86,44.8 69.94,44.8 69.99,44.75 69.99,44.59 69.82,44.42 69.82,44.17 70.05,43.94 70.46,43.94 70.64,44.11 70.64,44.55 70.68,44.59 70.84,44.59 71.36,45.12 v3(71.43,45.12) ; v2(92.46,37.94) v3(92.46,37.6)
  IN3 w0.089: v3(92.46,37.6) 92.66,37.41 92.66,37.38 92.83,37.21 94.62,37.21 95.23,36.6 95.23,35.75 96.5,34.48 96.5,27.92 94.44,25.86 90.63,25.86 89.44,24.67 84.01,24.67 83.35,24.01 80.13,24.01 75.36,28.78 75.36,29.12 74.4,30.08 74.4,32.38 74.16,32.62 74.16,41.6 73.69,42.07 73.38,42.07 72.93,41.62 72.47,41.62 72.3,41.79 72.3,41.91 72.4,42 72.78,42 73.01,42.24 73.01,42.58 72.55,43.04 72.17,43.04 71.71,42.58 71.54,42.58 71.41,42.71 71.41,43.24 71.18,43.47 70.8,43.47 70.26,42.93 70.12,42.93 69.76,43.3 69.76,44.15 69.87,44.26 69.98,44.26 70.16,44.08 70.48,44.08 71.06,44.67 71.06,44.72 71.43,45.09 v3(71.43,45.12)
DSI0_D0P: length 68.4
  TOP w0.071: v7(92.88,38.15) 92.74,38.01 91.87,38.01 91.72,38.16 91.23,38.16 U1001.T27
  IN1 w0.069: v2(92.87,37.88) 92.79,37.97 92.79,38.06 v7(92.88,38.15)
  IN2 w0.056: v2(69.37,44.86) 69.48,44.75 69.53,44.75 69.78,45 70.03,45 70.19,44.84 70.19,44.5 70.02,44.33 70.02,44.25 70.13,44.14 70.38,44.14 70.43,44.19 70.43,44.63 70.6,44.8 70.75,44.8 70.82,44.86 v3(70.82,45.12) ; v2(92.87,37.88) 92.87,37.66 92.97,37.56 v3(93.02,37.56)
  IN3 w0.089: v3(70.82,45.12) 70.82,44.77 70.38,44.33 70.26,44.33 70.08,44.5 69.77,44.5 69.52,44.25 69.52,43.2 70.02,42.69 70.36,42.69 70.9,43.23 71.08,43.23 71.17,43.14 71.17,42.61 71.44,42.33 71.81,42.33 72.27,42.8 72.45,42.8 72.77,42.48 72.77,42.34 72.68,42.25 72.3,42.25 72.06,42.01 72.06,41.69 72.37,41.38 73.03,41.38 73.48,41.83 73.59,41.83 73.92,41.5 73.92,32.52 74.16,32.28 74.16,29.98 75.12,29.02 75.12,28.68 80.03,23.77 83.45,23.77 84.11,24.43 89.54,24.43 90.73,25.62 94.54,25.62 96.74,27.82 96.74,34.58 95.47,35.85 95.47,36.7 94.72,37.45 93.11,37.45 93.02,37.54 v3(93.02,37.56)
DSI0_D1N: length 70.1
  TOP w0.071: v2(70.62,41.36) 69.58,41.36 R191.1 ; v8(93.12,37.18) 93.07,37.18 92.73,37.51 92.54,37.7 90.98,37.7 90.9,37.78 90.82,37.78 U1001.T26
  IN2 w0.056: v8(93.12,37.18) 93.22,37.18 93.58,37.53 93.58,37.85 93.63,37.89 93.63,38.36 93.68,38.42 v3(93.68,38.49) ; v2(70.62,41.36) 70.8,41.36 v3(70.95,41.2)
  IN3 w0.089: v3(70.95,41.2) 71.15,41.41 71.37,41.41 72.05,40.73 73.08,40.73 73.22,40.59 73.22,40.47 73.14,40.38 71.84,40.38 71.61,40.14 70.83,40.14 70.62,39.93 70.62,39.61 71.28,38.94 71.61,38.94 72.15,39.48 73.21,39.48 73.29,39.4 73.29,39.23 73.17,39.12 72.31,39.12 72.05,38.86 72.05,38.49 72.26,38.28 73.2,38.28 73.33,38.15 73.33,37.96 73.22,37.85 72.97,37.85 72.75,37.62 72.75,37.25 72.96,37.04 73.23,37.04 73.33,36.93 73.33,32.16 73.55,31.94 73.55,29.76 74.51,28.81 74.51,28.46 79.79,23.18 83.69,23.18 84.35,23.84 89.78,23.84 90.98,25.04 94.78,25.04 97.32,27.58 97.32,34.85 96.63,35.54 96.63,36.81 96.38,37.06 96.09,37.06 95.95,37.2 95.95,37.49 95.62,37.82 95.29,37.82 95.22,37.89 95.22,38.22 94.85,38.59 94.34,38.59 94.24,38.49 v3(93.68,38.49)
DSI0_D1P: length 70
  TOP w0.071: U1001.U26 90.72,37.65 90.85,37.65 90.93,37.57 92.36,37.57 92.57,37.35 92.65,37.27 92.65,37.16 v8(92.56,37.07) ; v2(70.59,41.76) 70.54,41.76 70.36,41.58 69.46,41.58 69.37,41.67 R194.1
  IN2 w0.056: v3(93.96,37.99) 93.96,37.94 93.78,37.76 93.78,37.45 93.18,36.85 92.94,36.85 92.84,36.95 92.84,37.23 92.76,37.31 92.64,37.31 92.56,37.23 v8(92.56,37.07) ; v2(70.59,41.76) 70.87,41.76 v3(70.93,41.81)
  IN3 w0.089: v3(93.96,37.99) 93.96,38.16 94.06,38.25 94.34,38.25 94.44,38.35 94.75,38.35 94.98,38.12 94.98,37.79 95.19,37.58 95.52,37.58 95.71,37.39 95.71,37.1 95.99,36.82 96.28,36.82 96.39,36.71 96.39,35.44 97.08,34.75 97.08,27.68 94.68,25.28 90.88,25.28 89.68,24.09 84.25,24.09 83.59,23.42 79.89,23.42 74.75,28.56 74.75,28.91 73.8,29.86 73.8,32.04 73.57,32.26 73.57,37.03 73.33,37.28 73.06,37.28 72.99,37.35 72.99,37.52 73.07,37.61 73.32,37.61 73.57,37.86 73.57,38.25 73.3,38.52 72.36,38.52 72.29,38.59 72.29,38.76 72.41,38.88 73.27,38.88 73.53,39.13 73.53,39.5 73.31,39.72 72.05,39.72 71.51,39.18 71.38,39.18 70.86,39.71 70.86,39.83 70.93,39.9 71.71,39.9 71.94,40.13 73.24,40.13 73.47,40.37 73.47,40.69 73.18,40.98 72.15,40.98 71.47,41.65 71.09,41.65 v3(70.93,41.81)
DSI0_D2N: length 69.3
  IN2 w0.056: v3(68.99,45.57) 69.13,45.7 69.37,45.7 v2(69.38,45.7) ; v3(92.36,38.52) 92.36,38.47 91.91,38.02 91.91,37.75 91.52,37.36 90.04,37.36 v8(89.84,37.16)
  IN3 w0.089: v3(68.99,45.57) 69.2,45.78 69.38,45.78 69.54,45.63 69.54,45.34 68.73,44.53 68.73,43.07 69.88,41.92 69.88,40.45 69.9,40.43 69.9,39.49 71.47,37.92 71.47,37.47 72.74,36.2 72.74,31.86 72.92,31.68 72.92,29.57 73.8,28.69 73.8,28.35 79.59,22.55 84.81,22.55 85.52,23.26 90.02,23.26 91.22,24.45 95.02,24.45 97.94,27.37 97.94,34.46 98.28,34.8 98.28,36.05 95.01,39.32 92.85,39.32 92.46,38.94 92.46,38.61 92.37,38.52 v3(92.36,38.52)
DSI0_D2P: length 69.2
  IN2 w0.056: v3(92.93,38.52) 92.97,38.49 92.97,38.22 92.91,38.16 92.34,38.16 92.11,37.94 92.11,37.67 91.6,37.16 v8(90.24,37.16) ; v3(69.02,46.48) 69.08,46.41 v2(69.38,46.41)
  IN3 w0.089: v3(92.93,38.52) 92.92,38.52 92.71,38.74 92.71,38.84 92.95,39.08 94.91,39.08 98.04,35.95 98.04,34.9 97.7,34.56 97.7,27.47 94.92,24.69 91.12,24.69 89.92,23.5 85.42,23.5 84.71,22.79 79.69,22.79 74.04,28.45 74.04,28.79 73.16,29.67 73.16,31.78 72.98,31.96 72.98,36.3 71.72,37.57 71.72,38.02 70.14,39.59 70.14,40.53 70.13,40.55 70.13,42.02 68.97,43.17 68.97,44.43 69.78,45.24 69.78,45.73 69.48,46.02 68.85,46.02 68.72,46.16 68.72,46.34 68.86,46.48 v3(69.02,46.48)
DSI0_D3N: length 71.4
  TOP w0.071: v2(70.37,40.6) 70.37,40.16 69.99,39.79 69.53,39.79 R184.1
  IN2 w0.056: v3(69.1,41.71) 69.28,41.53 69.59,41.53 70.24,40.88 70.24,40.72 v2(70.37,40.6) ; v3(90.94,38.56) 90.84,38.46 90.69,38.46 90.57,38.35 90.22,38.35 v8(89.84,37.96)
  IN3 w0.089: v3(90.94,38.56) 91.23,38.85 91.23,38.95 91.64,39.36 91.98,39.36 92.53,39.91 95.29,39.91 98.92,36.28 98.92,34.52 98.52,34.13 98.52,32.48 99.47,31.53 99.47,30 98.77,29.3 98.77,27.37 95.24,23.84 91.44,23.84 90.27,22.68 86.95,22.68 86.04,21.76 79.15,21.76 72.8,28.12 72.8,28.86 72.13,29.53 72.13,30.5 71.73,30.9 71.73,35.28 70.78,36.23 70.78,37.79 68.33,40.23 68.33,41.06 68.77,41.5 68.88,41.5 v3(69.1,41.71)
DSI0_D3P: length 71.4
  TOP w0.071: v2(69.91,40.6) 70.14,40.36 70.14,40.26 69.9,40.01 69.48,40.01 69.37,40.12 R185.1
  IN2 w0.056: v8(90.24,37.96) 90.24,38.07 90.31,38.15 90.66,38.15 90.77,38.26 91.11,38.26 91.39,38.54 v3(91.52,38.54) ; v3(69.05,40.77) 69.02,40.77 69.02,40.78 68.71,40.78 68.54,40.95 68.54,41.2 68.66,41.33 69.5,41.33 70.04,40.8 70.04,40.72 v2(69.91,40.6)
  IN3 w0.089: v3(91.52,38.54) 91.47,38.59 91.47,38.85 91.74,39.12 92.08,39.12 92.63,39.66 95.19,39.66 98.67,36.18 98.67,34.62 98.28,34.23 98.28,32.38 99.23,31.43 99.23,30.1 98.53,29.4 98.53,27.47 95.14,24.09 91.34,24.09 90.17,22.92 86.85,22.92 85.94,22 79.25,22 73.04,28.22 73.04,28.96 72.37,29.63 72.37,30.6 71.97,31 71.97,35.38 71.02,36.33 71.02,37.89 68.58,40.33 68.58,40.96 68.87,41.26 69.25,41.26 69.38,41.13 69.38,40.93 69.22,40.77 v3(69.05,40.77)
EAR_JACK_GND: length 3.3
  TOP w0.254: SH6204.1 9.64,23.25 R90776.2 8.96,24.01 9.69,24.75 10.49,24.75 U6541.A4
EAR_MIC_N: length 159.5
  TOP w0.102: v2(115.88,15.22) 115.73,15.22 115.32,14.82 115.32,12.98 113.98,11.64 113.98,11.18 v1(113.8,11)
  IN1 w0.102: v2(68.64,5.21) 68.59,5.16 68.59,5.03 68.71,4.91 69.3,4.91 69.38,4.98 72.45,4.98 79.64,12.17 85.58,12.17 88.5,9.25 92.31,9.25 93.07,8.49 112.36,8.49 113.32,9.44 113.32,10.34 113.76,10.79 113.76,10.96 v1(113.8,11)
  IN2 w0.102: v3(111.92,26.32) 112.15,26.09 112.15,25.41 113.32,24.24 113.95,24.24 114.84,23.35 114.84,22.72 115.83,21.73 115.83,18.17 116.09,17.92 116.09,15.42 v2(115.88,15.22) ; v3(8.6,24.6) 8.57,24.57 8.57,24.48 v2(8.1,24.01) ; v2(68.64,5.21) v3(68.64,5.54)
  IN3 w0.102: v3(8.6,24.6) 8.44,24.44 8.44,24.31 8.62,24.14 9.35,24.14 10.11,23.37 10.6,23.37 11.31,22.66 11.31,16.42 16.63,11.11 30.97,11.11 31.58,10.5 38.92,10.5 39.69,11.26 41.41,11.26 41.69,11.54 44.76,11.54 45.47,10.83 47.13,10.83 48.6,9.35 53.12,9.35 53.91,8.57 54.34,8.57 54.85,8.06 55.6,8.06 55.93,7.73 59.18,7.73 59.4,7.51 63.01,7.51 63.66,8.16 64.85,8.16 65.51,7.5 65.51,7.14 66.43,6.23 68.2,6.23 68.41,6.02 68.41,5.82 68.64,5.59 v3(68.64,5.54)
  IN4 w0.102: v5(103.72,28.36) 103.76,28.06 103.87,27.97 104.02,27.99 104.36,27.99 105.8,26.55 110.88,26.55 111.6,25.83 111.98,25.83 112.13,25.97 112.13,26.12 v3(111.92,26.32)
  BOTTOM w0.102: C6229.2 107.1,28.04 106.95,28.04 106.67,28.32 C10444.1 106.54,28.5 106.16,28.88 C10445.2 105.67,28.88 R6210.2 104.18,28.36 v5(103.72,28.36)
EAR_MIC_P: length 164.1
  TOP w0.102: v1(114.08,10.7) 114.16,10.78 114.16,11.56 115.5,12.91 115.5,14.74 115.56,14.8 v2(115.79,14.8)
  IN1 w0.102: v1(114.08,10.7) 114,10.62 113.85,10.62 113.5,10.27 113.5,9.37 112.44,8.31 93,8.31 92.24,9.07 88.43,9.07 85.5,11.99 79.71,11.99 72.53,4.81 69.45,4.81 69.38,4.73 68.64,4.73 68.16,5.21 v2(68.03,5.21)
  IN2 w0.102: v2(8.1,25.03) 8.1,24.76 v3(7.98,24.64) ; v2(115.79,14.8) 115.95,14.8 116.26,15.12 116.26,17.99 116.01,18.24 116.01,21.8 115.02,22.79 115.02,23.42 114.03,24.42 113.39,24.42 112.33,25.48 112.33,26.07 v3(112.53,26.27) ; v3(68.03,5.56) v2(68.03,5.21)
  IN3 w0.102: v3(7.98,24.64) 7.98,24.52 8.54,23.96 9.28,23.96 10.04,23.2 10.52,23.2 11.13,22.59 11.13,16.35 16.56,10.93 30.9,10.93 31.51,10.32 39,10.32 39.76,11.08 41.48,11.08 41.76,11.36 44.69,11.36 45.4,10.65 47.05,10.65 48.52,9.18 53.05,9.18 53.83,8.39 54.27,8.39 54.77,7.88 55.52,7.88 55.85,7.55 59.11,7.55 59.33,7.33 63.08,7.33 63.74,7.98 64.78,7.98 65.34,7.42 65.34,7.07 66.35,6.05 68.13,6.05 68.23,5.95 68.23,5.76 v3(68.03,5.56)
  IN4 w0.102: v3(112.53,26.27) 112.3,26.04 112.3,25.9 112.05,25.65 111.53,25.65 110.8,26.37 105.72,26.37 104.28,27.81 104.04,27.81 103.89,27.79 103.81,27.68 v5(103.85,27.37)
  BOTTOM w0.102: C6230.2 106.78,27.87 C10444.2 106.54,26.9 105.97,26.34 C6221.1 105.62,26.34 C6209.2 104.85,27.95 R6210.1 104.2,28.1 103.75,27.65 R90738.2 ; R6225.2 103.1,26.72 R90738.2 ; v5(103.85,27.37) R90738.2
EC_AP_INT_ODL: length 65.1
  IN1 w0.076: v7(90.24,39.96) 90.26,39.98 92.21,39.98 93.18,40.95 93.81,40.95 94.17,40.6 95.18,40.6 v1(95.54,40.95) 95.72,40.95 96.07,40.6 96.07,40.32 97.19,39.2 97.19,36.94 97.63,36.5 97.63,35.7 98.43,34.89 98.43,32.8 99.6,31.63 99.73,31.63 100.59,30.77 102.85,30.77 103.31,30.31 103.31,30.28 v2(103.3,30.28) ; v1(124.34,50.42) 124.34,50.39 124.01,50.07 124.01,49.42 123.35,48.75 123.35,48.52 122.6,47.78 122.6,46.94 122,46.34 122,45.44 121.29,44.73 121.29,43.77 118.52,41 118.52,32.77 118.35,32.59 118.35,28.78 117.61,28.05 v2(117.61,28)
  IN2 w0.058: v2(117.61,28) 117.39,28.22 115.41,28.22 114.8,27.6 110.31,27.6 109.37,26.67 109.24,26.67 108.79,26.21 107.57,26.21 107.47,26.11 105.25,26.11 104.22,27.13 104.22,27.97 103.04,29.16 103.04,30.02 v2(103.3,30.28)
EC_BATT_PRES_ODL: length 82.2
  TOP w0.089: R90893.2 126.17,54.03 126.49,54.35 126.79,54.35 127.12,54.68 129.61,54.68 130.24,55.3 130.75,55.3 131.43,54.62 132.15,54.62 132.95,53.81 132.95,50.93 132.79,50.77 132.79,50.28 135.01,48.06 135.01,43.64 v2(135.11,43.54)
  IN2 w0.058: v2(135.11,43.54) 136.79,43.54 139.52,40.81 139.52,37.38 140.97,35.93 140.97,35.17 141.41,34.73 141.41,25.02 140.77,24.38 140.77,23.04 139.87,22.13 135.03,22.13 132.27,19.36 127.59,19.36 126.96,18.72 123.86,18.72 123.43,18.3 120.3,18.3 119.11,17.1 119.11,16.81 v3(118.3,16.01)
  IN3 w0.102: v3(113.39,10.34) 113.39,11.04 112.73,11.7 112.73,12.6 113.52,13.39 114.01,13.39 114.36,13.74 115.61,13.74 117.88,16.01 v3(118.3,16.01)
  IN4 w0.058: v3(113.39,10.34) 113.19,10.14 112.88,10.14 112.55,10.46 111.38,10.46 110.73,9.81 v5(110.73,9.5)
EC_BL_EN_OD: length 120.8
  TOP w0.089: D2739.2 41.83,37.95 Q705.1 41.75,38.86 40.95,39.66 40.79,39.66 39.07,41.39 38.72,41.39 38.6,41.5 38.6,44.01 39.31,44.72 39.31,44.88 40.09,45.65 42.39,45.65 42.61,45.87 46.65,45.87 47.17,46.4 53.41,46.4 53.7,46.11 56.36,46.11 58.36,48.1 59.3,48.1 60.43,49.23 63.41,49.23 63.48,49.16 67.34,49.16 67.42,49.23 v2(67.52,49.23) ; D2739.2 41.71,36.97 R91199.2 ; D2739.2 D2738.2 ; v2(122.79,48.52) 122.89,48.42 U6517.A8
  IN2 w0.058: v3(68.08,48.77) 67.62,49.23 v2(67.52,49.23) ; v3(123.11,48.84) v2(122.79,48.52)
  IN3 w0.102: v3(68.08,48.77) 68.46,48.77 69.97,50.28 69.97,53.03 70.59,53.65 70.59,58.14 71.8,59.34 72.92,59.34 77.37,63.79 115.68,63.79 118.96,60.51 118.96,56.93 122.16,53.73 122.16,49.79 v3(123.11,48.84)
EC_BOARD_ID: length 7.3
  TOP w0.089: U6517.E3 126.34,50.42 126.6,50.68 128.38,50.68 128.63,50.93 R90472.1 129.26,50.56 129.37,50.45 129.79,50.45 129.95,50.29 129.95,48.53 R90473.1 130.04,48.27 129.49,47.73 C10379.1
EC_BOARD_ID_EN_ODL: length 3.1
  TOP w0.089: C10379.2 129.04,47.91 129.26,48.13 R90473.2 127.81,48.44 U6517.B1
EC_BOOT0: length 148.3
  TOP w0.089: Q8.3 37.53,6.22 R90450.1 36.81,5.5 36.81,4.63 v2(37.24,4.2) ; v2(61.1,16.03) 61.02,16.11 61.02,17.02 61.12,17.13 61.12,17.43 60.59,17.96 R90449.2
  IN1 w0.076: v1(125.84,48.92) 125.84,48.14 125.48,47.78 124.98,47.78 124.8,47.61 124.8,45.68 124.37,45.24 123.17,45.24 122.39,44.46 v2(122.39,43.41)
  IN2 w0.058: v2(37.24,4.2) 38.35,3.1 47.47,3.1 49.84,5.47 49.84,6.43 50.23,6.82 50.23,8 50.98,8.75 50.98,10.33 53.56,12.91 53.86,12.91 53.98,12.78 54.21,12.78 54.43,13 54.43,13.3 54.85,13.72 57.49,13.72 58.56,14.79 59.9,14.79 60.89,15.78 60.89,15.83 v2(61.1,16.03) 61.48,16.03 v3(61.5,16.06) ; v3(122.79,43.41) v2(122.39,43.41)
  IN3 w0.102: v3(61.5,16.06) 61.68,15.88 61.68,13.83 64.93,10.57 69.13,10.57 70.11,11.55 86.1,11.55 87.26,10.38 89.28,10.38 91.51,8.15 114.15,8.15 115.19,9.19 115.19,10.19 115.88,10.88 116.27,10.88 116.98,11.58 117.88,11.58 120.28,13.98 122.31,13.98 123.53,15.19 123.53,18.81 121.5,20.84 121.5,26.58 121.5,26.59 121.5,27.51 121.5,27.52 121.5,27.69 120.91,28.28 120.91,33.71 122.54,35.34 122.54,40.16 122.79,40.42 v3(122.79,43.41)
EC_BOOT_DFU: length 2.1
  TOP w0.089: U124.J5 58.4,17.41 58.96,17.96 R90449.1
EC_CCD_MODE_ODL: length 237
  TOP w0.089: U6517.H2 126.84,52.26 127.05,52.47 127.76,52.47 128.13,52.84 128.13,53.98 128.34,54.2 129.82,54.2 130.31,54.69 v1(130.51,54.69)
  IN1 w0.076: v2(74.74,65.21) 74.71,65.23 74.71,66.68 75.45,67.42 124.04,67.42 125.48,65.97 125.48,60.34 123.96,58.81 123.96,58.19 122.89,57.13 122.89,56.71 123.47,56.14 123.91,56.14 124.34,56.57 126.25,56.57 126.35,56.47 127.19,56.47 127.74,57.03 130.54,57.03 131.05,56.52 131.68,56.52 131.81,56.39 131.81,55 131.63,54.82 130.64,54.82 v1(130.51,54.69)
  IN2 w0.058: v2(54.08,13.12) 54.06,13.14 53.48,13.14 50.77,10.43 50.77,8.84 50.02,8.09 50.02,6.99 49.56,6.53 49.56,5.49 47.4,3.33 38.64,3.33 36.95,5.02 36.95,6.13 34.21,8.88 32.73,8.88 30.55,11.06 29.95,11.06 29.51,11.5 21.3,11.5 20.89,11.1 16.55,11.1 14.44,13.21 14.44,18.1 14.15,18.39 14.15,19.81 16.65,22.3 16.65,24.05 16.53,24.17 16.53,25.88 16.21,26.2 v3(16.21,27.1) 16.21,27.37 16.34,27.51 16.34,28.21 16.13,28.42 15.83,28.42 15.13,29.11 15.13,29.3 14.31,30.12 14.31,30.87 14.94,31.5 14.94,31.94 15.1,32.1 15.1,32.43 15.59,32.92 15.59,33.3 15.34,33.55 15.34,34.52 16,35.17 16.27,35.17 18.11,37.02 18.11,37.88 17.11,38.88 17.11,41.82 17.37,42.08 17.37,42.13 18.1,42.85 18.49,42.85 19.64,44 22.63,44 23.7,45.08 24.14,45.08 24.49,44.74 24.87,44.74 24.95,44.81 25.76,44.81 26.6,45.65 27.5,45.65 28.05,46.21 34.88,46.21 35.09,46 37.69,46 38.13,46.44 38.8,46.44 39.85,47.5 42.35,47.5 42.89,48.04 57.68,48.04 57.8,48.15 58.93,48.15 60.26,49.48 62.36,49.48 63.1,50.23 63.94,50.23 68.14,54.43 68.14,58.77 71.61,62.24 71.87,62.24 74.74,65.1 v2(74.74,65.21)
  IN4 w0.058: v5(16.29,27.46) 16.29,27.18 v3(16.21,27.1)
EC_ENTERING_RW: length 6.1
  TOP w0.089: R90375.1 51.12,21.08 51.51,20.69 Q717.3 51.51,19.75 52.03,19.23 52.03,18.83 v2(52.28,18.57)
  IN2 w0.058: v2(53.98,17.41) 52.74,17.41 52.15,17.99 52.15,18.45 v2(52.28,18.57)
EC_ENTERING_RW_ODL: length 116.2
  IN1 w0.076: v2(118.68,18.95) 118.68,21.39 118.17,21.9 118.17,25.83 118.6,26.26 118.6,28.38 118.96,28.73 118.96,30.28 119.52,30.84 119.58,30.84 119.8,31.06 119.8,32.77 118.98,33.59 118.98,40.8 121.9,43.72 121.9,44.68 122.94,45.73 123.16,45.73 v1(123.3,45.86) 123.3,46.49 123.93,47.12 123.93,48.65 124.57,49.28 124.57,50.66 v1(124.84,50.92)
  IN2 w0.058: v3(50.55,19.39) 50.55,19.46 50.81,19.72 v2(50.81,20.55) ; v3(118.3,18.95) v2(118.68,18.95)
  IN3 w0.102: v3(118.3,18.95) 117.76,18.42 117.76,16.75 115.36,14.35 114.11,14.35 113.76,14 113.27,14 109.61,10.34 99.91,10.34 99.66,10.09 91.29,10.09 89.77,11.61 87.84,11.61 86.69,12.77 69.6,12.77 69.36,12.53 64.7,12.53 62.9,14.33 62.9,17.24 62.4,17.74 61.2,17.74 61.04,17.58 60.65,17.58 59.99,18.24 58.81,18.24 57.67,19.39 55.14,19.39 54.52,20.01 51.12,20.01 50.55,19.44 v3(50.55,19.39)
EC_FLASH_WP_ODL: length 136.9
  TOP w0.089: R90610.2 44.56,24.57 45.06,25.06 45.06,25.54 46.06,26.55 46.06,30.25 44.86,31.45 44.86,32.84 45.03,33 45.6,33 46.4,33.8 51.29,33.8 51.54,34.04 55.1,34.04 55.77,34.71 55.77,35.02 57.95,37.19 57.95,43.01 57.49,43.47 57.49,45.37 v1(57.69,45.57) ; v1(120.46,56.34) 121.24,55.56 121.24,52.57 121.61,52.2 122.45,52.2 122.58,52.08 122.58,51.63 122.87,51.34 122.87,50.48 123.1,50.25 123.6,50.25 123.78,50.42 U6517.E8
  IN1 w0.076: v1(57.69,45.57) 58.73,45.57 59.47,46.31 62.91,46.31 65.31,48.71 66.34,48.71 67.8,50.17 69.03,50.17 70.05,51.19 70.05,56.81 74.6,61.36 74.6,64.56 75.07,65.03 75.07,66.71 75.55,67.19 122.56,67.19 123.14,66.6 123.89,66.6 124.93,65.57 124.93,60.64 122.94,58.65 122.23,58.65 120.76,57.18 120.76,56.65 v1(120.46,56.34)
EC_I2C1_1V8_SCL: length 197.2
  TOP w0.089: R91117.1 23.7,42.75 23.79,42.84 23.97,42.84 24.06,42.75 24.06,41.55 24.36,41.25 25,41.25 25.19,41.45 25.19,41.75 25.39,41.95 v2(25.48,41.95) ; U6517.B3 126.6,48.66 126.6,47.88 127.23,47.25 127.65,47.25 R90521.2 127.81,46.16 127.81,45.15 128.2,44.76 132.9,44.76 133.05,44.61 133.33,44.61 v2(133.43,44.71) ; Q787.1 140.96,24.13 v2(141.08,24.01)
  IN2 w0.058: v3(133.05,44.84) 133.18,44.71 v2(133.43,44.71) 133.57,44.57 134.7,44.57 135.39,43.89 137.05,43.89 139.85,41.09 139.85,37.56 141.34,36.07 141.34,35.34 141.74,34.94 141.74,28.11 142.16,27.69 142.16,27.12 141.64,26.6 141.64,24.57 v2(141.08,24.01) ; 25.22,41.95 25.16,41.89 25.16,41.74 25.33,41.58 25.61,41.58 26.04,41.14 26.04,39.34 25.2,38.49 25.2,37.94 23.59,36.34 23.07,36.34 23.01,36.28 23.01,35.93 v3(23.25,35.69) ; 25.22,41.95 v2(25.48,41.95) ; 25.22,41.95 25.16,42 25.16,42.41 25.46,42.7 26.09,42.7 28.08,44.68 28.08,45.45 28.3,45.67 34.66,45.67 34.87,45.46 37.95,45.46 38.39,45.9 39.02,45.9 40.04,46.92 42.65,46.92 43.21,47.48 47.31,47.48 47.32,47.49 57.9,47.49 58.02,47.61 59.15,47.61 60.48,48.94 62.58,48.94 63.32,49.69 64.17,49.69 68.68,54.2 68.68,57.3 73.21,61.83 73.21,62.79 76.88,66.45 117.72,66.45 118.87,65.31 120.53,65.31 121.13,65.9 123.17,65.9 123.55,66.28 v3(123.55,66.4)
  IN3 w0.102: v3(123.55,66.4) 123.91,66.05 124.86,66.05 126.07,64.84 126.07,63.89 125.05,62.87 125.05,59.47 126.88,57.64 127.84,57.64 131.02,54.46 131.02,50.96 131.68,50.3 131.94,50.3 132.39,49.84 132.39,44.72 132.49,44.62 132.84,44.62 v3(133.05,44.84)
  IN4 w0.058: v5(23.25,36.07) v3(23.25,35.69)
  BOTTOM w0.089: v5(23.25,36.07) 23.25,36.33 22.82,36.77 22.82,36.83 22.21,37.45 21.8,37.45 21.15,38.1 Q783.1
EC_I2C1_1V8_SDA: length 193
  TOP w0.089: R91118.1 23.7,43.11 23.79,43.02 24.05,43.02 24.24,42.83 24.24,41.63 24.43,41.43 24.93,41.43 25.01,41.52 25.01,41.75 24.82,41.95 v2(24.72,41.95) ; U6517.A3 126.42,48.33 126.42,47.81 127.21,47.02 127.21,46.65 R90522.2 127.63,46.18 127.63,45.08 128.13,44.58 132.82,44.58 132.98,44.43 133.27,44.43 v2(133.43,44.26) ; v2(141.84,27.31) 141.16,27.31 140.96,27.51 Q788.1
  IN2 w0.058: 24.99,41.95 25.05,41.89 25.05,41.7 25.28,41.46 25.56,41.46 25.93,41.09 25.93,39.39 25.08,38.54 25.08,37.99 23.54,36.46 23.02,36.46 22.89,36.33 22.89,35.95 v3(22.64,35.69) ; 24.99,41.95 v2(24.72,41.95) ; 24.99,41.95 25.05,42 25.05,42.45 25.41,42.82 26.05,42.82 27.96,44.73 27.96,45.5 28.25,45.79 34.71,45.79 34.91,45.58 37.9,45.58 38.34,46.02 38.97,46.02 39.99,47.04 42.61,47.04 43.17,47.6 47.26,47.6 47.27,47.61 57.85,47.61 57.97,47.73 59.1,47.73 60.44,49.06 62.53,49.06 63.28,49.81 64.12,49.81 68.57,54.25 68.57,57.35 73.09,61.88 73.09,62.83 76.83,66.57 117.77,66.57 118.92,65.43 120.48,65.43 121.08,66.02 122.66,66.02 122.95,66.31 122.95,66.39 v3(122.94,66.4) ; v3(133.05,44.2) 133.11,44.26 v2(133.43,44.26) 133.63,44.46 134.65,44.46 135.34,43.77 137,43.77 139.73,41.04 139.73,37.51 141.22,36.02 141.22,35.3 141.62,34.9 141.62,28.06 142.05,27.64 142.05,27.51 v2(141.84,27.31)
  IN3 w0.102: v3(122.94,66.4) 122.94,66.35 123.45,65.84 124.77,65.84 125.87,64.75 125.87,63.97 124.85,62.96 124.85,59.38 126.8,57.44 127.76,57.44 130.82,54.38 130.82,50.87 131.6,50.09 131.85,50.09 132.19,49.76 132.19,44.64 132.41,44.42 132.83,44.42 133.04,44.2 v3(133.05,44.2)
  IN4 w0.058: v5(22.64,36.07) v3(22.64,35.69)
  BOTTOM w0.089: Q784.1 20.35,35.81 21.8,37.27 22.13,37.27 22.64,36.76 v5(22.64,36.07)
EC_I2C1_3V3_SCL: length 4.2
  TOP w0.089: Q787.3 140.67,23.19 140.35,22.87 R91210.2 140.35,21.9 140.11,21.67 140.11,20.41 140.03,20.33 R91205.2
EC_I2C1_3V3_SDA: length 8.3
  TOP w0.089: R91204.2 138.19,20.5 137.88,20.81 137.88,22.41 140.09,24.62 R91211.2 140.09,26.07 140.52,26.49 Q788.3
EC_I2C2_1V8_SCL: length 68.3
  TOP w0.089: v2(147.07,27.18) 144.84,24.95 144.84,24.44 144.43,24.03 143.42,24.03 143.2,24.26 Q757.1 ; v2(148.73,33.32) 148.85,33.45 150.57,33.45 150.66,33.35 Q726.3 ; v2(122.04,50.63) 122.04,50.42 122.28,50.17 122.46,50.17 122.69,49.94 122.69,49.66 123.09,49.26 123.67,49.26 U6517.C8
  IN2 w0.058: v2(122.04,50.63) 122.27,50.4 122.64,50.4 122.79,50.55 v3(123,50.55) ; v3(120.12,57.28) 119.85,57.56 119.85,57.85 120.71,58.72 120.71,58.95 v2(120.97,59.21) ; v2(148.73,33.32) v3(148.32,33.32) 148.05,33.58 147.68,33.58 147.39,33.3 147.39,27.5 v2(147.07,27.18)
  IN3 w0.102: v3(148.32,33.32) 148.78,33.78 148.78,34.48 147.95,35.31 146.6,35.31 144.7,37.22 142.05,37.22 140.7,38.56 136.08,38.56 135.65,39 133.46,39 130.23,42.22 127.41,42.22 127.01,42.63 127.01,46.16 126.37,46.79 126.37,48.49 125.76,49.1 124.77,49.1 123.55,50.32 123.22,50.32 v3(123,50.55) 122.89,50.45 122.72,50.45 122.61,50.56 122.61,53.92 119.87,56.66 119.87,57.03 v3(120.12,57.28)
EC_I2C2_1V8_SDA: length 65.8
  TOP w0.089: v2(122.04,49.61) 122.04,49.75 122.28,49.99 122.39,49.99 122.51,49.87 122.51,49.59 123.02,49.08 123.67,49.08 U6517.B8 ; v2(148.73,33.79) 148.89,33.62 150.57,33.62 150.66,33.71 Q725.3 ; Q759.1 143.25,27.46 143.42,27.29 146.67,27.29 v2(147.07,27.69)
  IN2 w0.058: v3(123,49.89) 122.49,49.89 122.21,49.61 v2(122.04,49.61) ; v3(119.47,57.28) 119.73,57.54 119.73,57.9 120.59,58.77 120.59,59.08 v2(120.47,59.21) ; v2(148.73,33.79) 148.57,33.79 v3(148.32,34.04) 147.98,33.7 147.64,33.7 147.28,33.34 147.28,27.9 v2(147.07,27.69)
  IN3 w0.102: v3(148.32,34.04) 148.55,34.28 148.55,34.42 147.86,35.11 146.52,35.11 144.61,37.01 141.96,37.01 140.61,38.36 136,38.36 135.57,38.79 133.38,38.79 130.15,42.02 127.33,42.02 126.81,42.54 126.81,46.07 126.17,46.71 126.17,48.41 125.68,48.9 124.69,48.9 123.47,50.12 123.22,50.12 v3(123,49.89) 122.41,50.48 122.41,53.83 119.67,56.58 119.67,57.09 v3(119.47,57.28)
EC_I2C2_1V8_SENSOR_SCL: length 48.8
  TOP w0.089: R91219.1 R90515.2 148.61,32.55 148.7,32.46 148.7,31.98 148.79,31.89 v2(149.28,31.89)
  IN2 w0.058: v2(149.28,31.89) 149.28,33.74 148.95,34.07 148.95,36.97 v2(148.58,37.34) 148.57,37.35 148.58,37.47 148.58,38.49 v3(149.08,39)
  IN3 w0.102: v3(130.23,58.91) 130.39,58.76 132.11,58.76 133.1,57.77 133.99,57.77 135.19,56.57 135.19,54.46 136.06,53.59 136.06,48.09 136.15,48 136.15,46.13 137.47,44.81 138.64,44.81 141.35,42.11 143.45,42.11 144.71,40.85 146.82,40.85 148.67,39 v3(149.08,39)
  IN4 w0.058: v5(129.5,63.35) 128.99,63.35 128.5,62.86 128.5,60.06 128.78,59.78 129.36,59.78 129.73,59.4 129.73,59.24 130.06,58.91 v3(130.23,58.91)
