# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AP_TXD1_BT_RXD: length 93.2
  TOP w0.089: TP9064.1 78.24,43.72 v2(78.11,43.59)
  IN1 w0.06: 80.89,41.81 81.18,41.52 81.19,41.52 81.34,41.36 81.64,41.36 v7(81.83,41.16)
  IN1 w0.076: 80.89,41.81 80.88,41.82 80.88,41.84 80.84,41.88 80.82,41.88 79.51,43.19 78.19,43.19 78,43.37 78,43.48 v2(78.11,43.59)
  IN2 w0.058: v3(129.01,60.81) 129.01,60.84 129.28,61.1 129.28,61.48 129.11,61.65 128.55,61.65 127.94,62.26 125.62,62.26 124.58,61.22 123.83,61.22 123.43,60.81 122.18,60.81 121.65,61.35 120.25,61.35 120.02,61.12 117.99,61.12 116.05,63.06 94.65,63.06 94.29,62.7 79.86,62.7 76.4,59.24 76.4,45.66 77.28,44.79 77.28,44.53 77.93,43.88 77.93,43.79 77.99,43.73 77.99,43.71 v2(78.11,43.59)
  IN3 w0.102: v3(139.45,61.35) 139.24,61.56 139.24,61.84 138.95,62.13 129.93,62.13 129.22,61.42 129.22,61.04 129.01,60.84 v3(129.01,60.81)
  IN4 w0.058: v3(139.45,61.35) v5(139.45,61.02)
  BOTTOM w0.089: U1007.56 139.39,60.24 139.23,60.4 139.23,60.79 v5(139.45,61.02)
AP_UART_VREF: length 4.2
  BOTTOM w0.203: R330.1 44.46,12.09 C415.1 44.46,10.52 44.5,10.48 CON16.18
AP_WARM_RST_REQ: length 57.1
  IN1 w0.076: v2(114.33,51.06) 114.28,51.06 114.03,51.31 104.75,51.31 104.39,50.95 103,50.95 102.91,50.86 99.96,50.86 99.47,50.37 99.47,48.39 99.36,48.27 99.36,48 98.31,46.95 98.31,45.44 97.19,44.32 97.19,44.18 97.11,44.1 v2(97.11,44.08)
  IN2 w0.058: v2(114.33,51.06) 114.33,50.91 116,49.24 116,48.78 118.11,46.67 122.18,46.67 122.68,47.17 124.6,47.17 124.93,46.84 125.93,46.84 126.6,47.5 v3(127.39,47.5) ; v2(127.57,53.96) 127.41,53.96 v3(127.12,54.25)
  IN2 w0.06: v8(89.04,40.36) 89.2,40.2 91.07,40.2 91.69,40.82
  IN2 w0.075: 91.69,40.82 93.04,40.82 93.62,41.41 93.84,41.41 94.09,41.66 95,41.66 95.23,41.43 95.51,41.43 95.87,41.79 95.87,42.02 96.02,42.17 96.02,43.12 96.98,44.08 v2(97.11,44.08)
  IN3 w0.102: v3(127.39,47.5) 127.36,47.53 127.36,48.09 127.57,48.29 127.57,50.48 126.68,51.36 126.68,53.57 127.12,54.02 v3(127.12,54.25)
AU_HPL: length 52.7
  TOP w0.203: R6206.1 v2(106.4,27.13) 106.4,26.88 106.13,26.61 R90773.1
  IN2 w0.203: v8(106.78,36.84) 106.82,36.84 107.17,37.2 107.17,37.88 v3(107.12,37.94) ; v3(114.93,47.3) 115.02,47.21 115.02,46.04 118.14,42.91 118.14,34.08 117.65,33.58 116.98,33.58 115.03,31.64 115.03,30.98 114.36,30.31 114.36,29.71 113.99,29.33 109.22,29.33 107.91,28.02 107.45,28.02 107.33,27.9 106.84,27.9 106.4,27.46 v2(106.4,27.13)
  IN4 w0.203: v4(107.02,39.23) 107.02,39.21 107.12,39.1 v3(107.12,37.94) ; v4(114.94,47.63) 114.93,47.62 v3(114.93,47.3)
  IN5 w0.203: v4(114.94,47.63) 114.94,48.04 114.87,48.11 114.87,49.37 114.1,50.13 110.94,50.13 108.67,47.86 108.67,43.35 108.29,42.97 108.29,42.11 106.84,40.66 106.84,39.41 v4(107.02,39.23)
AU_HPR: length 56.7
  TOP w0.203: v2(107.07,27.13) 107.07,26.8 107.1,26.77 R90774.1 ; v8(106.79,36.41) 106.66,36.41 106.42,36.65 U2001.G4
  IN2 w0.203: v2(107.07,27.13) 107.15,27.21 108.07,27.21 109.53,28.66 114.31,28.66 115.07,29.42 115.07,29.97 115.8,30.7 115.8,31.45 117.21,32.87 117.89,32.87 118.8,33.78 118.8,43.21 115.73,46.29 v3(115.73,47.22) ; v8(106.79,36.41) 106.79,36.21 v3(106.64,36.06)
  IN4 w0.203: v3(115.73,47.22) v4(115.73,47.55) ; v4(106.71,36.44) 106.71,36.13 v3(106.64,36.06)
  IN5 w0.203: v4(115.73,47.55) 115.73,48.57 115.6,48.7 115.6,49.61 114.39,50.83 110.63,50.83 107.97,48.17 107.97,43.67 107.6,43.3 107.6,42.4 106.13,40.93 106.13,39.22 106.33,39.02 106.33,37.96 106.47,37.82 106.47,36.68 v4(106.71,36.44)
AU_MICBIAS0: length 103.5
  TOP w0.203: v1(78.11,27.54) 78.37,27.54 78.72,27.18 81.01,27.18 81.52,27.69 83.04,27.69 83.88,28.53 83.88,29.14 84.23,29.49 84.23,32.27 84.56,32.6 v2(84.59,32.6)
  IN1 w0.203: v1(78.11,27.54) 78.04,27.62 76.26,27.62 74.35,29.52 74.35,30.84 72.47,32.72 70.34,32.72 69.91,33.15 68.18,33.15 67.27,32.24 64.5,32.24 62.24,34.49 62.13,34.49 61.16,35.46 60.31,35.46 60.22,35.55 58.7,35.55 56.99,37.26 55.85,37.26 49.3,43.81 46.63,43.81 44.18,41.36 44.18,41.11 41.55,38.47 38.43,38.47 35.8,41.1 v2(35.8,41.33)
  IN2 w0.203: v2(84.59,32.6) 84.59,32.86 v3(84.67,32.94) ; v8(107.6,37.19) 107.65,37.14 107.65,37.12 107.97,36.81 v3(107.97,36.45) ; v3(34.03,34.87) 34.03,34.97 33.99,35.01 33.99,35.39 33.74,35.64 33.74,39.27 v2(35.8,41.33)
  IN4 w0.203: v5(85.33,32.94) v3(84.67,32.94) ; v3(34.03,34.87) 34.03,34.56 v5(33.99,34.52) ; v3(107.97,36.45) 107.97,35.84 108.11,35.69 108.11,35.04 v5(107.93,34.86)
  BOTTOM w0.203: v5(85.33,32.94) 85.46,32.8 88.18,32.8 90.37,34.99 90.37,35.12 90.71,35.46 91.88,35.46 92.21,35.79 98.56,35.79 99.09,35.27 100.58,35.27 100.88,35.57 107.23,35.57 v5(107.93,34.86) 108.31,34.48 C6102.2 ; v5(33.99,34.52) 33.99,35.31 34.05,35.37 J15.1
AU_MICBIAS1: length 26.9
  IN1 w0.06: 108.53,36.45 108.22,36.75 108.22,36.96 108.02,37.16 v7(108.02,37.25)
  IN1 w0.203: v2(103.89,25.83) 105.61,25.83 106.07,26.28 107.51,26.28 110.24,29.01 112.12,29.01 113.27,30.16 113.27,32.22 112.86,32.62 112.31,32.62 111.34,33.58 110.99,33.58 110.84,33.43 109.91,33.43 v2(109.69,33.66) 109.74,33.71 109.74,34.48 109.45,34.76 109.45,35.14 108.9,35.7 108.77,35.7 108.53,35.94 108.53,36.45
  IN2 w0.203: v3(109.35,33.8) 109.54,33.8 v2(109.69,33.66) ; v2(103.89,25.83) 103.16,26.56 v3(103.16,27.67)
  IN4 w0.203: v5(109.58,34.17) 109.55,34.17 109.35,33.97 v3(109.35,33.8) ; v5(102.97,27.37) 102.97,27.47 v3(103.16,27.67)
  BOTTOM w0.203: v5(102.97,27.37) 102.94,27.4 R6209.2 ; C6103.2 109.33,34.3 109.46,34.17 v5(109.58,34.17)
AU_REFN: length 209
  TOP w0.076: v1(115.79,24.62) 115.67,24.74 112.85,24.74 112,25.59 107.88,25.59 107.38,25.09 106.78,25.09 106.64,25.24 106.64,26.61 106.74,26.71 106.74,27.39 106.97,27.62 v2(107.63,27.62) 108.07,27.62 C10447.1 ; v2(117.04,14.98) 117.04,14.88 116.82,14.66 116.82,13.99 116.49,13.66 116.49,12.24 115.15,10.9 v1(115.15,10.19)
  IN1 w0.076: v2(117.11,18.8) 117.06,18.8 116.72,19.14 116.72,23.37 115.79,24.29 v1(115.79,24.62) ; v1(115.15,10.19) 115.15,9.52 112.87,7.24 92.41,7.24 91.81,7.84 87.4,7.84 84.66,10.59 80.33,10.59 75.35,5.61 75.35,4.41 73.51,2.57 63.18,2.57 62.1,3.66 58.22,3.66 57.6,4.27 55.38,4.27 53.21,2.11 19.67,2.11 18,3.77 18,7.66 14.58,11.08 14.58,12.24 11.2,15.63 11.2,21.37 10.51,22.06 v1(10.51,22.1)
  IN2 w0.076: v2(117.04,14.98) 117.21,15.15 117.21,18.7 v2(117.11,18.8) ; v3(115.28,47.99) 115.33,47.93 115.33,46.18 118.47,43.03 118.47,33.93 117.79,33.25 117.1,33.25 115.42,31.58 115.42,30.86 114.72,30.16 114.72,29.53 114.19,29 109.37,29 107.98,27.62 v2(107.63,27.62) ; v8(106.78,37.22) 106.78,37.25 106.72,37.31 106.72,37.47 v3(106.65,37.54)
  IN4 w0.076: v4(106.74,38.26) 106.64,38.16 106.64,37.55 v3(106.65,37.54) ; v3(115.28,47.99) v4(115.28,48.32)
  IN5 w0.076: v4(115.28,48.32) 115.28,48.52 115.28,48.52 115.28,49.48 114.22,50.54 110.79,50.54 108.3,48.05 108.3,43.43 107.92,43.05 107.92,42.26 106.53,40.86 106.53,39.28 106.66,39.15 106.66,38.33 v4(106.74,38.26)
AU_VIN1_N: length 10.6
  IN1 w0.06: 108.49,35.06 108.49,35.54 108.22,35.81 108.22,36.28 v7(108.05,36.45)
  IN1 w0.102: v2(108.64,31.2) 108.72,31.27 108.72,32.09 108.32,32.49 108.32,33 108.75,33.43 108.75,34.6 108.49,34.86 108.49,35.06
  IN2 w0.102: v2(108.64,31.2) 108.64,31.07 108.54,30.96 108.54,30.3 v3(108.09,29.85)
  IN4 w0.102: v3(108.09,29.85) 108.3,29.63 108.3,29.13 108.77,28.66 108.77,28.1 108.56,27.88 108.25,27.88 108.15,27.98 v5(108.15,28.3)
AU_VIN1_P: length 11.3
  IN1 w0.06: 108.67,35.06 108.67,35.53 108.34,35.86 108.34,36.45 108.02,36.76 v7(108.02,36.85)
  IN1 w0.102: 108.67,35.06 108.67,34.93 108.92,34.68 108.92,33.36 108.49,32.93 108.49,32.57 108.9,32.16 108.9,30.85 v2(108.85,30.8)
  IN2 w0.102: v3(108.69,29.85) 108.59,29.96 108.59,30.1 108.72,30.23 108.72,30.67 v2(108.85,30.8)
  IN4 w0.102: v3(108.69,29.85) 108.48,29.63 108.48,29.2 108.95,28.73 108.95,28.02 108.63,27.7 108.25,27.7 108.15,27.6 v5(108.15,27.29)
AUD_CLK_MISO: length 36.4
  IN1 w0.06: 106.19,33.98 106.19,34.32 106.32,34.46 106.32,36.07 106.22,36.17 106.22,38.23 106.65,38.65 106.65,38.9 106.82,39.07 v7(106.82,39.25) ; v7(90.24,39.56) 90.3,39.63 90.42,39.63 90.47,39.68 90.51,39.68
  IN1 w0.076: 106.19,33.98 106.19,31.74 v2(106.1,31.65) ; 90.51,39.68 90.54,39.71 93.46,39.71 93.53,39.78 93.94,39.78 94.27,39.45 94.78,39.45 94.9,39.33 95.58,39.33 96.16,38.74 96.16,36.72 95.99,36.56 95.99,35.01 96.83,34.17 96.83,32.08 97.65,31.26 97.65,30.99 98.92,29.72 v1(98.92,29.62) 100.69,27.84 102.93,27.84 103.03,27.74 104.28,27.74 105.24,28.71 105.67,28.71 105.8,28.84 106.07,28.84 106.45,29.22 106.45,29.61 106.36,29.7 v2(106.36,30.13)
  IN2 w0.058: v2(106.1,31.65) 106.31,31.45 106.31,30.84 106.26,30.79 106.26,30.24 v2(106.36,30.13)
AUD_CLK_MOSI: length 36.3
  IN1 w0.06: v7(89.83,39.56) 90.03,39.76 90.38,39.76 90.44,39.81 ; 106.65,34 106.65,34.07 106.68,34.1 106.68,36.22 106.58,36.32 106.58,38.05 106.85,38.31 107.44,38.31 107.55,38.43 107.55,38.5 107.83,38.77 107.83,39.53 107.95,39.65 v7(108.02,39.65)
  IN1 w0.076: 106.65,34 106.65,30.86 106.23,30.44 106.12,30.44 105.34,29.66 105.34,29.5 104.25,28.4 102.78,28.4 102.68,28.3 101.2,28.3 100.69,28.81 100.52,28.81 v1(100.22,29.1) 98.1,31.22 98.1,31.48 97.29,32.29 97.29,34.37 96.48,35.19 96.48,36.53 96.45,36.56 96.45,38.89 95.72,39.63 95,39.63 94.7,39.93 93.43,39.93 93.34,39.85 90.44,39.85 90.44,39.84 90.44,39.81
AUD_DAT_MISO0: length 40
  TOP w0.089: v1(95.76,38.46) 95.76,38.66 96.05,38.95 R1007.1
  IN1 w0.06: 90.53,39.51 90.49,39.47 90.43,39.47 90.32,39.36 90.03,39.36 v7(89.83,39.16)
  IN1 w0.076: 90.53,39.51 90.58,39.51 90.64,39.57 93.43,39.57 94.7,38.31 95.61,38.31 v1(95.76,38.46) 95.85,38.37 95.85,37.85 95.66,37.66 95.66,37.32 95.46,37.12 95.46,36.76 95.39,36.69 95.39,35.67 95.33,35.62 95.33,35.01 96.38,33.97 96.38,31.86 97.19,31.05 97.19,30.55 v1(97.5,30.24) 100.45,27.29 102.27,27.29 102.37,27.18 104.38,27.18 105.32,28.12 106.15,28.12 106.91,28.88 106.91,30.47 v2(106.81,30.56)
  IN2 w0.058: v2(106.81,30.56) 106.73,30.64 106.73,32.14 106.84,32.25 106.84,33.83 106.55,34.12 106.55,35.15 106.62,35.22 106.62,35.65 106.34,35.93 106.34,36.25 106.56,36.46 106.56,37.12 106.35,37.32 106.35,37.81 106.89,38.34 106.89,39.37 v8(107.22,39.7)
AUD_DAT_MISO1: length 20.8
  IN1 w0.06: v7(89.44,39.96) 89.54,39.96 89.87,40.29 91.55,40.29
  IN1 w0.076: 91.55,40.29 92.11,40.29 93.05,41.23 94.09,41.23 v2(94.34,40.97)
  IN2 w0.058: v3(106.94,40.05) 106.94,39.76 v8(106.84,39.66) ; v3(94.7,40.92) 94.39,40.92 v2(94.34,40.97)
  IN3 w0.102: v3(106.94,40.05) 107.15,40.25 107.15,40.9 106.84,41.2 106.23,41.2 105.82,40.8 104.68,40.8 104.33,40.44 101.61,40.44 101.35,40.7 97.26,40.7 96.55,41.41 95.66,41.41 95.18,40.92 v3(94.7,40.92)
AUD_DAT_MOSI0: length 23.3
  TOP w0.089: R1009.1 R1012.2 v2(94.98,42.02)
  IN2 w0.058: v3(107.55,39.3) 107.22,38.97 v8(107.22,38.82) ; v3(95.36,42.02) v2(94.98,42.02) 94.85,42.14 94.16,42.14 93.73,41.72 93.53,41.72 92.99,41.17 91.66,41.17 91.06,40.57 89.66,40.57 89.63,40.54 89.32,40.54 89.1,40.76 v8(89.04,40.76)
  IN3 w0.102: v3(107.55,39.3) 107.35,39.5 107.35,41 106.94,41.41 106.13,41.41 105.72,41 104.53,41 104.22,40.7 101.74,40.7 101.48,40.95 97.39,40.95 96.68,41.66 95.72,41.66 v3(95.36,42.02)
AUD_DAT_MOSI1: length 37
  TOP w0.089: U1001.N27 91.12,39.07 93.33,39.07 93.66,38.73 94.38,38.73 94.52,38.59 v2(94.9,38.59)
  IN1 w0.06: v7(108.02,39.25) 107.95,39.17 107.95,38.71 107.7,38.47 107.7,38.39 107.5,38.19 107.08,38.19 106.98,38.1 106.98,36.59 107.01,36.57 107.01,36.31 106.8,36.1 106.8,33.92
  IN1 w0.076: 106.8,33.92 106.8,30.98 107.14,30.65 107.14,28.77 106.26,27.9 105.42,27.9 104.48,26.96 102.27,26.96 102.17,27.06 100.29,27.06 99.28,28.06 v1(99.18,28.06) 96.96,30.28 96.96,30.94 96.15,31.76 96.15,33.86 95.11,34.91 95.11,35.72 95.16,35.77 v2(95.16,36.94)
  IN2 w0.058: v2(95.16,36.94) 94.93,37.17 94.93,38.56 94.9,38.59 v2(94.9,38.59)
AUD_SYNC_MISO: length 33.4
  TOP w0.075: v1(93.1,40.29) 92.97,40.42 92.54,40.42 91.95,39.82 90.9,39.82 U1001.M26
  IN1 w0.06: v7(107.22,39.25) 107.17,39.25 106.77,38.85 106.77,38.6 106.34,38.18 106.34,36.22 106.44,36.12 106.44,34.37 106.35,34.28 106.35,34
  IN1 w0.076: v1(93.1,40.29) 93.35,40.54 93.53,40.54 93.74,40.34 95.16,40.34 95.41,40.09 95.87,40.09 96.9,39.06 96.9,36.72 97.12,36.5 97.12,36.29 97.16,36.25 97.16,35.49 97.98,34.68 97.98,32.59 98.99,31.58 98.99,31.32 100.08,30.23 v1(100.21,30.23) 100.26,30.23 101.3,29.19 103.79,29.19 104.45,29.85 104.45,29.95 104.91,30.41 v1(105,30.41) 105.01,30.41 106.01,31.4 106.19,31.4 106.35,31.56 106.35,34
AUD_SYNC_MOSI: length 34
  TOP w0.075: U1001.L26 90.81,39.96 90.82,39.97 91.8,39.97
  TOP w0.089: 91.8,39.97 92.41,40.58 93.15,40.58 v1(93.43,40.3)
  IN1 w0.06: v7(107.62,39.25) 107.62,39.25 107.4,39.03 107.12,39.03 106.89,38.8 106.89,38.55 106.46,38.13 106.46,36.27 106.56,36.17 106.56,34.17 106.5,34.11 106.5,34
  IN1 w0.076: 106.5,34 106.5,31.46 105.12,30.08 104.91,30.08 104.68,29.85 104.68,29.62 v1(104.02,28.96) 101.2,28.96 100.29,29.88 100.11,29.88 98.76,31.22 98.76,31.48 97.75,32.49 97.75,34.58 96.93,35.39 96.93,36.48 96.76,36.66 96.76,38.99 95.82,39.93 95.36,39.93 95.1,40.2 93.53,40.2 v1(93.43,40.3)
AUX_IN0_NTC: length 15.9
  TOP w0.089: NTC1501.1 80.53,25.91 80.75,26.12 R1501.2 81.51,26.6 84.56,26.6 84.72,26.75 85.71,26.75 86.24,27.28 86.24,28.3 86.5,28.56 87.54,28.56 87.82,28.84 87.82,29.27 87.71,29.37 87.71,29.65 v1(87.69,29.67)
  IN1 w0.06: 88.32,32.39 88.32,33.21 88.03,33.49 88.03,33.64 87.83,33.84 87.83,33.86 v2(87.81,33.88)
  IN1 w0.076: 88.32,32.39 88.32,30.89 87.71,30.28 87.71,29.7 v1(87.69,29.67)
  IN2 w0.058: v3(87.87,33.53) 87.87,33.83 v2(87.81,33.88)
  IN4 w0.058: v5(87.87,33.18) v3(87.87,33.53)
AUX_IN1_NTC: length 68.5
  TOP w0.089: NTC1502.1 119.19,48.69 v2(119.19,47.88)
  IN1 w0.06: 87.86,32.39 87.86,32.93 87.75,33.04 87.75,33.36 87.64,33.48 87.64,33.75 87.43,33.95 v7(87.43,33.96) 87.1,33.96 87.05,33.92 v2(87.03,33.92)
  IN1 w0.076: 87.86,32.39 87.86,31.09 87.13,30.36 87.13,29.34 86.6,28.81 v2(86.6,28.48)
  IN2 w0.058: v3(86.72,33.79) 86.85,33.92 v2(87.03,33.92) ; v3(116.19,49.92) 116.82,49.92 118.86,47.88 v2(119.19,47.88) ; v2(86.6,28.48) 86.4,28.48 86.34,28.42 86.34,28.41 86.28,28.35 v3(86.17,28.35)
  IN4 w0.058: v4(116.37,49.08) 116.16,49.28 116.16,49.84 116.19,49.87 v3(116.19,49.92) ; v5(87.03,34.33) 87.03,34.09 v3(86.72,33.79) ; v5(86.6,28.05) 86.29,28.35 v3(86.17,28.35)
  IN5 w0.076: v5(105.77,23.76) 106.15,23.76 106.79,24.39 106.92,24.39 107.68,25.15 109.33,25.15 109.58,25.41 109.71,25.41 110.73,26.42 110.73,26.93 113.7,29.9 113.7,31.3 113.9,31.5 113.9,44.05 115.12,45.27 115.62,45.27 116.37,46.02 v4(116.37,49.08)
  BOTTOM w0.089: v5(86.6,28.05) 86.6,24.77 87.46,23.91 105.62,23.91 v5(105.77,23.76)
AUXIN2: length 16.7
  TOP w0.089: v2(85.99,24.75) 86.22,24.75 86.52,24.44 87.41,24.44 87.7,24.73 89.3,24.73 89.75,25.18 R90732.1 R90729.1
  IN2 w0.058: v8(87.84,34.36) 88.08,34.36 v3(88.15,34.3) 88.51,33.94 88.51,30.96 87.48,29.93 87.48,29.62 87.13,29.28 87.13,27.87 86.42,27.16 86.42,25.13 86.04,24.75 v2(85.99,24.75)
  IN4 w0.058: v3(88.15,34.3) 88.18,34.33 v5(88.5,34.33)
BASE_ACCEL_INT_ODL: length 29.6
  TOP w0.089: v1(131.55,40.14) 131.68,40.27 137.83,40.27 142.15,35.95 R90568.1
  IN1 w0.076: v1(126.34,51.92) 127.6,51.92 128.08,51.44 128.08,50.91 128.94,50.04 128.94,49.16 129.47,48.63 131.1,48.63 131.66,48.07 131.66,46.46 131.22,46.03 131.22,41.59 131.66,41.15 131.66,40.24 v1(131.55,40.14)
BATADC: length 2.7
  IN2 w0.058: v3(109.2,41.31) 108.62,41.31 108.02,40.72 v8(108.02,40.45)
  IN4 w0.058: v5(109.54,40.95) 109.54,40.98 v3(109.2,41.31)
  BOTTOM w0.089: C2302.1 v5(109.54,40.95)
BATON: length 6.9
  IN2 w0.058: v8(108.02,40.05) 108.02,40.08 108.22,40.28 108.22,40.61 108.41,40.8 108.42,40.8 108.62,41 109.59,41 109.94,41.35 109.94,41.69 110.19,41.94 111.26,41.94 v3(111.26,41.95)
  IN4 w0.058: v5(111.06,42.3) 111.06,42.15 v3(111.26,41.95)
  BOTTOM w0.089: v5(111.06,42.3) 111.06,42.08 111.24,41.9 112.24,41.9 R2301.2
BATT_DISABLE_ODL: length 55.7
  TOP w0.089: Q55.2 95.13,8.48 C299.1 95.09,8.49 R420.2 93.61,8.49 92.93,9.17 v1(92.93,9.72)
  IN1 w0.076: v1(92.93,9.72) 92.9,9.75 88.7,9.75 85.8,12.66 79.41,12.66 72.32,5.57 v2(70.71,5.57) ; v1(54.48,18.91) 54.31,18.74 54.31,16.77 54.52,16.57 56.96,16.57 v2(57.46,16.06)
  IN2 w0.058: v3(70.33,5.57) v2(70.71,5.57) ; v3(57.79,15.91) 57.76,15.94 57.58,15.94 v2(57.46,16.06)
  IN3 w0.102: v3(57.79,15.91) 58.04,15.91 59.31,14.64 60.08,14.64 60.46,14.25 60.46,13.32 61.25,12.53 61.25,11.43 62.36,10.32 63.46,10.32 64.45,9.33 67.03,9.33 68.58,7.78 68.58,7.11 69.63,6.06 69.95,6.06 70.33,5.68 v3(70.33,5.57)
BATT_SCL_1V8: length 7.3
  TOP w0.089: U6517.F4 125.59,51.17 125.59,52.42 125.75,52.59 125.75,54.2 126.71,55.15 R91248.2 128.73,55.15 Q793.1
BATT_SCL_3V3: length 106.3
  TOP w0.089: R91296.2 143.97,21.88 v2(144.23,21.62) ; v2(132.95,54.77) 132.76,54.77 132.43,55.1 131.71,55.1 131.43,55.38 R91246.2 131.22,55.53 130.74,56.01 Q793.3
  IN2 w0.058: v2(132.95,54.77) v3(133.33,54.77) ; v3(146.44,28.58) 146.25,28.77 146.02,28.77 145.96,28.71 145.96,27.49 146.24,27.21 146.24,26.75 144.43,24.95 144.43,21.82 v2(144.23,21.62) 144.13,21.52 144.13,20.58 143.47,19.92 143.47,17.63 142.66,16.83 138.08,16.83 136.89,18.01 136.05,18.01 133.79,15.75 127.77,15.75 126.26,14.24 125.18,14.24 123.41,12.48 120.12,12.48 118.74,11.1 118.74,10.62 117.86,9.74 113.15,9.74 112.21,10.68 100.39,10.68 100.03,11.04 100.03,11.04 v3(100.05,11.06)
  IN3 w0.102: v3(146.44,28.58) 146.69,28.84 147.9,28.84 150.83,31.77 150.83,35.43 148.7,37.57 148.19,37.57 147.92,37.85 146.58,37.85 145.44,39 143.77,39 141.99,40.77 140.81,40.77 138.1,43.49 135.34,43.49 134.83,44 134.83,47.45 134.74,47.54 134.74,53.04 133.87,53.92 133.87,54.36 133.46,54.77 v3(133.33,54.77)
  IN4 w0.058: v5(99.7,11.05) 99.71,11.06 v3(100.05,11.06)
BATT_SDA_1V8: length 5.4
  TOP w0.089: Q794.1 125.23,55.79 R91249.2 124.82,54.88 125.51,54.2 125.51,52.69 125.34,52.51 U6517.H5
BATT_SDA_3V3: length 108.2
  TOP w0.089: v2(132.95,54.36) 132.82,54.36 132.33,54.86 131.53,54.86 130.84,55.56 129.98,55.56 129.6,55.94 129.6,56.75 129.4,56.95 128.68,56.95 128.53,56.8 128.53,56.29 128.41,56.17 R91247.2 127.9,56.17 127.47,55.73 Q794.3
  IN2 w0.058: v3(133.41,54.16) 133.21,54.36 v2(132.95,54.36) ; v3(101.28,11.06) 101.45,10.89 112.3,10.89 113.23,9.95 117.77,9.95 118.53,10.71 118.53,11.19 120.05,12.71 123.34,12.71 125.09,14.45 126.16,14.45 127.68,15.97 133.7,15.97 135.97,18.24 136.97,18.24 138.13,17.08 142.62,17.08 143.24,17.7 143.24,20 143.9,20.66 143.9,21.75 144.22,22.07 144.22,25.07 145.93,26.78 v2(145.93,26.88) 145.93,27.21 145.75,27.39 145.75,28.8 145.93,28.98 146.21,28.98 v3(146.44,29.22)
  IN3 w0.102: v3(133.41,54.16) 133.41,53.94 134.44,52.91 134.44,47.42 134.53,47.33 134.53,43.8 135.14,43.19 137.97,43.19 140.69,40.47 141.87,40.47 143.64,38.69 145.31,38.69 146.46,37.54 147.79,37.54 148.06,37.27 148.57,37.27 150.53,35.31 150.53,31.9 147.77,29.14 146.52,29.14 v3(146.44,29.22)
  IN4 w0.058: v3(101.28,11.06) 101.69,11.06 v5(101.7,11.05)
BATT_TEMP: length 51.3
  TOP w0.089: 119.16,36.41 R91184.1 ; 119.16,36.41 119.16,36.01 119.32,35.85 v2(120.63,35.85) ; 119.16,36.41 R91183.1
  IN2 w0.058: v2(120.63,35.85) v3(120.63,36.18)
  IN3 w0.102: v3(120.63,36.18) 120,35.54 120,31.47 120,31.46 120,30.58 120,30.58 120,28.45 119.87,28.33 119.87,26.63 120.4,26.09 120.4,18.73 119.59,17.91 119.59,15.48 115.89,11.79 115.47,11.79 v3(114.02,10.34)
  IN4 w0.058: v3(114.02,10.34) 113.61,9.93 112.79,9.93 112.46,10.25 111.46,10.25 111.05,9.84 111.05,9.38 110.83,9.15 110.83,8.79 v5(110.73,8.69) 110.4,9.02 99.27,9.02 97.7,10.59 v5(97.7,11.05)
BB_BATGONE: length 0.6
  TOP w0.089: R538.1 119.6,36.4 R91184.2
BC12_C0_ADDR: length 1.6
  TOP w0.089: U6555.10 19.09,43.64 18.65,44.08 R91062.1
BC12_C0_EN_L: length 1.4
  TOP w0.089: R91061.1 18.65,43.19 18.71,43.24 U6555.11
BC12_EC_INT_ODL: length 134.9
  TOP w0.089: v1(120.35,56.75) 120.05,56.44 120.05,56.27 121,55.31 121,52.47 121.58,51.89 R91179.1 ; v2(24.09,43.52) 24.06,43.52 23.88,43.69 23.3,43.69 23.14,43.85 R619.2 22.87,44.1 22.41,43.64 U6555.5
  IN1 w0.076: v2(75.38,65.78) 75.38,66.67 75.62,66.91 122.51,66.91 123.05,66.38 123.73,66.38 124.7,65.41 124.7,60.74 122.84,58.88 122.13,58.88 120.35,57.11 v1(120.35,56.75)
  IN2 w0.058: v2(75.38,65.78) 75.38,65.42 72.86,62.89 72.86,61.98 68.35,57.48 68.35,54.34 64.03,50.02 63.19,50.02 62.44,49.27 60.35,49.27 59.01,47.94 57.88,47.94 57.76,47.82 49.68,47.82 49.68,47.83 42.98,47.83 42.44,47.29 39.94,47.29 38.88,46.23 38.21,46.23 37.77,45.79 35,45.79 34.8,46 28.14,46 27.75,45.6 27.75,44.82 26.04,43.12 24.61,43.12 24.21,43.52 v2(24.09,43.52)
BMM150_CSB: length 3.1
  TOP w0.089: R91146.2 146.67,41.94 147.66,42.93 U6575.A5
BMM150_SDO: length 3.7
  TOP w0.089: R91144.2 149.72,44.79 U6575.C1
BOOTBLOCK_EC_CLK: length 9.5
  TOP w0.089: v2(116.26,53.8) 116.17,53.8 115.71,54.26 U6522.9 ; U6517.G8 123.83,51.42 123.43,51.82 122.97,51.82 v2(122.92,51.87)
  IN2 w0.058: v2(116.26,53.8) 116.29,53.78 117.46,53.78 117.64,53.6 118.11,53.6 119.79,51.92 122.87,51.92 v2(122.92,51.87)
BOOTBLOCK_EC_CMD: length 13.6
  TOP w0.089: U6522.16 v2(113.69,56.03)
  IN2 w0.058: v2(124.34,50.92) 124.01,51.25 124.01,52.03 123.06,52.99 119.47,52.99 117.7,54.77 114.96,54.77 v2(113.69,56.03)
BOOTBLOCK_EC_DAT0: length 12.1
  TOP w0.089: U6522.3 114.46,54.66 v2(114.54,54.74)
  IN2 w0.058: v2(114.54,54.74) 114.73,54.54 117.68,54.54 119.46,52.76 123.04,52.76 123.84,51.96 v2(123.84,50.92)
BOOTBLOCK_EN_L: length 101.6
  TOP w0.089: v2(115.45,58.43) 115.43,58.43 115.31,58.31 113.61,58.31 R90692.2 113.91,57.52 R91031.1
  IN1 w0.06: 80.02,34.98 80.07,34.93 80.54,34.93 81.37,35.75 81.72,35.75 81.73,35.76 82.03,35.76 v7(82.24,35.96) 82.24,35.96 82.43,36.16 82.43,36.49 82.5,36.56 82.73,36.56 82.83,36.66 82.83,36.95 82.76,37.02 82.76,39.66 82.84,39.74 82.84,40.91 v2(82.99,41.06)
  IN1 w0.076: v1(76.49,29.34) 77.07,29.93 77.3,29.93 77.78,30.41 77.78,30.89 77.94,31.05 77.94,31.35 78.34,31.76 78.34,33.84 78.83,34.33 78.83,34.84 79.15,35.16 79.84,35.16 80.02,34.98
  IN2 w0.058: v2(129.62,49.28) 129.62,51.77 128,53.4 119.59,53.4 118.46,54.53 118.46,55.09 118.3,55.25 117.74,55.25 115.71,57.28 115.71,58.17 v2(115.45,58.43) 114.8,58.43 111.42,61.81 95.75,61.81 94.88,60.95 80.41,60.95 79.11,59.65 ; 82.2,41.22 81.12,41.22 80.37,41.96 80.37,42.07 78.34,44.11 78.3,44.11 77.78,44.63 77.78,44.9 76.84,45.84 76.84,55.14 77.33,55.63 77.33,57.3 77.73,57.71
  IN2 w0.06: 82.2,41.22 82.57,41.22 82.66,41.14 82.91,41.14 v2(82.99,41.06) ; 77.73,57.71 77.73,58.27 79.11,59.65
BT_EN_1V8: length 94.4
  TOP w0.089: Q724.1 134.21,64.73 133.94,65.01 v2(133.73,65.01)
  IN1 w0.06: v7(82.64,40.36) 82.44,40.16 81.27,40.16 80.88,40.55 80.78,40.55
  IN1 w0.076: 80.78,40.55 80.57,40.77 80.27,40.77 79.4,41.64 78.14,41.64 77.15,42.63 75.42,42.63 72.14,45.9 72.14,51.75 v2(72.27,51.87)
  IN2 w0.058: v2(133.73,65.01) 134.08,64.66 134.08,64.23 133.75,63.9 133.39,63.9 132.91,63.43 130.29,63.43 130.14,63.57 122.55,63.57 122.24,63.88 118.26,63.88 117.1,65.04 77.47,65.04 75.71,63.29 75.71,62.24 72.59,59.11 72.59,57.52 72.4,57.33 72.4,53.42 72.93,52.89 72.93,52.28 72.53,51.87 v2(72.27,51.87)
BT_EN_3V3: length 10.2
  TOP w0.089: R90627.2 R90901.2 136.19,63.53 136.02,63.35 Q724.3
  IN2 w0.058: v3(143.24,59.76) 142.81,60.2 142.58,60.2 v2(142.35,60.43) 142.07,60.71 141.33,60.71 139.17,62.87 138.39,62.87 v2(137.73,63.52)
  IN4 w0.058: v3(143.24,59.76) v5(142.89,59.76)
BT_HOST_WAKE: length 76.1
  TOP w0.075: U1001.AF26 91.17,33.96 91.54,33.59 91.54,33.37 91.96,32.95 91.96,32.48
  TOP w0.089: v1(91.88,32.04) 91.88,32.31 91.96,32.39 91.96,32.48 ; R90844.1 143.42,43.32 142.74,42.64 127.07,42.64 125.26,40.82 v2(123.88,40.82)
  IN1 w0.076: v2(111.16,27.29) 111.16,26.83 110.4,26.07 108.15,26.07 107.77,25.69 106.33,25.69 105.82,25.18 103.46,25.18 103.08,25.56 101.25,25.56 100.82,25.13 97.72,25.13 96.81,26.04 96.02,26.04 94.98,27.08 94.83,27.08 94.19,27.72 93.91,27.72 93.33,28.3 93.33,28.72 92.13,29.91 92.13,31.02 92.01,31.15 92.01,31.88 91.88,32.01 v1(91.88,32.04)
  IN2 w0.058: v2(123.88,40.82) 123.88,40.69 123.11,39.91 123.11,35.79 121.66,34.35 121.66,33.97 120.62,32.92 120.62,32.16 120.34,31.89 120.34,27.64 119.82,27.12 116.2,27.12 115.92,27.39 111.27,27.39 v2(111.16,27.29)
BTN_GND: length 33.1
  TOP w0.089: v1(138.34,10.7) 138.26,10.78 134.83,10.78 134.37,11.23 130.95,11.23 v2(130.47,11.7)
  IN1 w0.076: v1(138.34,10.7) 139.33,11.69 140.85,11.69 v1(141.62,10.93)
  IN2 w0.058: v3(123.81,9.32) 124.01,9.53 v2(124.01,9.69) 124.01,10.1 124.96,11.05 127.58,11.05 127.92,11.4 128.98,11.4 129.49,11.91 130.26,11.91 v2(130.47,11.7)
  IN4 w0.058: v3(123.81,9.32) v5(123.81,9.66)
  BOTTOM w0.089: CON9105.27 121.22,19.48 124.24,16.47 CON7102.27 124.24,10.09 v5(123.81,9.66)
BUCKBOOST_ACIN: length 7.2
  TOP w0.089: R503.2 123.1,39.04 123.1,38.23 C533.2 124.12,37.21 124.12,36.58 123.57,36.03 R504.1 123.78,35.82 124.7,35.82 125.3,35.22 U6.19
BUCKBOOST_ASGATE: length 184.8
  TOP w0.089: v2(32.21,47.64) Q795.2 ; v2(127.97,33.61) 127.97,33.13 127.52,32.67 127.39,32.67 127.31,32.59 U6.13 ; Q801.4 30.1,41.55 30.38,41.27 v2(30.38,40.35)
  IN1 w0.076: v2(30.38,40.35) 30.38,38.88 30.64,38.61 33.14,38.61 v1(33.55,38.2)
  IN2 w0.058: v2(30.38,40.35) 30.67,40.65 32.14,40.65 33.79,42.3 v3(33.79,42.42) ; v3(62.42,9.21) 62.44,9.21 63.41,8.25 63.98,8.25 64.44,8.71 66.5,8.71 67.06,8.16 68.17,8.16 68.73,8.71 69.44,8.71 70.1,8.06 74.64,8.06 78.16,11.57 79.61,12.19 81.21,12.81 85.74,12.81 86.67,11.87 89.15,11.87 92.21,8.82 118.24,8.82 v3(119.85,10.42) ; v3(32.61,47.64) v2(32.21,47.64) ; v2(127.97,33.61) 127.97,32.87 v3(127.74,32.65)
  IN3 w0.102: v3(127.74,32.65) 127.4,32.3 126.4,32.3 126.25,32.15 126.25,30.99 126.1,30.84 124.58,30.84 123.35,29.61 123.35,29.25 123.23,29.13 123.23,22.13 126.32,19.04 126.32,16.39 125.97,16.03 125.97,15.07 123.02,12.13 122,12.13 120.29,10.42 v3(119.85,10.42) ; v3(33.79,42.42) 35.21,43.85 35.21,45.4 32.97,47.64 v3(32.61,47.64)
  IN4 w0.058: v4(60.69,10.14) 60.87,10.14 61.02,9.99 61.27,9.99 61.48,9.78 61.82,9.78 62.39,9.21 v3(62.42,9.21) ; v3(33.79,42.42) 33.79,42.25 34.73,41.31 39.43,41.31 40.17,42.04 45.4,42.04 46.66,43.3 48.62,43.3 49.69,42.23 v4(50.57,42.23)
  IN5 w0.076: v4(50.57,42.23) 50.57,42.07 51.62,41.01 54.01,41.01 57.92,37.11 57.92,36.86 60.46,34.31 60.46,28.6 58.38,26.52 53.46,26.52 51.86,24.92 51.86,21.3 51.86,21.3 51.86,20.07 52.32,19.62 52.32,19.37 53.04,18.65 53.04,18.23 53.3,17.97 53.71,17.97 53.97,17.72 54.35,17.72 55.76,16.3 55.76,15.83 56.19,15.4 56.92,15.4 57.34,14.99 57.34,14.57 60,11.91 60,11.23 60.69,10.53 v4(60.69,10.14)
BUCKBOOST_CMIN: length 5.4
  TOP w0.089: U6.20 124.9,35.24 124.57,35.57 123.3,35.57 123.11,35.76 123.11,36.91 122.97,37.05 R521.1 R91192.2
BUCKBOOST_CMOUT: length 1.8
  TOP w0.089: U6.26 122.23,33.39 122.07,33.56 122.07,34.27 TP110.1
BUCKBOOST_COMP: length 4.1
  TOP w0.089: C10452.1 119.76,33.39 120.03,33.12 120.84,33.12 R90740.2 121.51,33.35 121.51,33.02 121.94,32.59 U6.28
BUCKBOOST_CSN: length 167.4
  TOP w0.203: C447.2 38.3,46.96 37.83,46.49 R90837.2 ; C447.2 39.51,46.96 C10492.1 ; C447.2 v1(38.59,46.69) ; U6.14 127.35,32.99 127.37,33 v2(127.38,33)
  IN1 w0.203: v2(40.42,42.93) 40.31,43.04 40.31,43.53 40,43.83 40,45.76 39.19,46.57 38.71,46.57 v1(38.59,46.69)
  IN2 w0.203: v2(40.42,42.93) 40.42,42.63 v3(40.44,42.6) ; v3(63.03,9.17) 63.03,9.02 63.52,8.53 63.86,8.53 64.33,9 66.62,9 67.18,8.44 68.05,8.44 68.61,9 69.55,9 70.21,8.34 74.53,8.34 78.12,11.93 81.16,13.09 85.86,13.09 86.79,12.15 89.27,12.15 91.15,10.27 99.34,10.27 99.57,10.04 111.94,10.04 112.88,9.1 118.13,9.1 119.38,10.36 119.38,10.67 119.74,11.03 v3(119.85,11.03) ; v3(127.13,32.75) v2(127.38,33)
  IN3 w0.203: v3(119.85,11.03) 120.11,11.03 121.63,12.54 122.84,12.54 124.9,14.61 124.9,19.39 122.88,21.41 122.88,29.28 123,29.4 123,31.63 122.48,32.14 122.48,33.16 123.36,34.04 126.02,34.04 127.13,32.93 v3(127.13,32.75)
  IN4 w0.203: v3(63.03,9.17) 63.03,9.17 63.03,9.44 62.8,9.67 62.36,9.67 61.94,10.09 v4(61.62,10.09) ; v3(40.44,42.6) 40.24,42.81 40.24,42.95 40.35,43.06 40.94,43.06 41.67,42.32 45.28,42.32 46.54,43.58 49.6,43.58 50.34,42.85 v4(50.58,42.85)
  IN5 w0.203: v4(50.58,42.85) 50.84,42.85 50.96,42.72 50.96,42.09 51.74,41.31 54.13,41.31 58.21,37.23 58.21,36.98 60.75,34.44 60.75,27.47 59.51,26.23 53.59,26.23 52.15,24.8 52.15,21.42 52.16,21.42 52.16,20.19 52.61,19.74 52.61,19.49 53.3,18.8 54.32,18.8 54.54,18.58 54.54,18.38 56.84,16.08 56.84,15.9 57.63,15.11 57.63,14.69 60.29,12.03 60.29,11.35 61.55,10.09 v4(61.62,10.09)
BUCKBOOST_CSP: length 166
  TOP w0.203: C10491.1 39.28,45.76 C447.1 ; C447.1 37.58,45.76 R90836.2 ; C447.1 v1(38.59,46.03)
  IN1 w0.203: v2(39.84,42.93) 39.96,43.05 39.96,43.38 39.65,43.68 39.65,45.61 39.05,46.21 38.77,46.21 v1(38.59,46.03)
  IN2 w0.203: v3(63.65,9.06) 63.95,9.35 66.77,9.35 67.18,8.94 68.05,8.94 68.46,9.35 69.7,9.35 70.36,8.69 74.38,8.69 77.92,12.23 81.09,13.44 86,13.44 86.94,12.51 89.42,12.51 91.3,10.63 99.48,10.63 99.72,10.39 112.09,10.39 113.03,9.46 117.98,9.46 119.03,10.5 119.03,10.86 119.81,11.64 v3(119.85,11.64) ; v2(39.84,42.93) v3(39.84,42.58) ; v3(127.12,33.67) v2(127.39,33.41)
  IN3 w0.203: v3(119.85,11.64) 120.11,11.64 121.43,12.95 122.67,12.95 124.5,14.78 124.5,19.22 122.47,21.24 122.47,29.45 122.59,29.57 122.59,31.46 122.08,31.97 122.08,33.33 123.19,34.44 126.19,34.44 126.96,33.67 v3(127.12,33.67)
  IN4 w0.203: v4(50.58,43.25) 50.47,43.25 49.78,43.94 46.4,43.94 45.14,42.68 41.82,42.68 41.09,43.41 40.21,43.41 39.89,43.09 39.89,42.63 v3(39.84,42.58) ; v4(61.68,10.5) 62.04,10.5 62.51,10.03 62.95,10.03 63.65,9.33 v3(63.65,9.06)
  IN5 w0.203: v4(61.68,10.5) 61.64,10.5 60.64,11.5 60.64,12.18 57.98,14.84 57.98,15.26 57.19,16.05 57.19,16.23 54.9,18.53 54.9,18.72 54.46,19.16 53.44,19.16 52.97,19.64 52.97,19.89 52.51,20.34 52.51,21.57 52.51,24.65 53.73,25.88 59.66,25.88 61.11,27.32 61.11,34.58 58.56,37.13 58.56,37.38 54.28,41.66 51.89,41.66 51.32,42.23 51.32,42.87 50.94,43.25 v4(50.58,43.25)
CHARGER_IADP: length 1
  TOP w0.089: R91195.1 120.49,32.82 C495.1
CHARGER_PMON: length 2.7
  TOP w0.089: U6.30 121.73,31.79 121.32,31.38 R174.2 120.51,31.38 C594.1
CHRLDO: length 6.7
  IN2 w0.058: v8(107.62,40.45) 107.62,40.62 108.8,41.79 109.18,41.79 109.5,42.1 109.98,42.1 110.2,42.33 v3(110.47,42.33)
  IN4 w0.058: v3(110.47,42.33) 110.47,42.46 110.7,42.68 110.7,42.71 110.98,42.99 v5(110.98,43.06)
  BOTTOM w0.089: R2304.2 112.35,43.14 111.9,43.59 111.26,43.59 111.06,43.39 111.06,43.14 v5(110.98,43.06)
CKDN: length 3.7
  TOP w0.071: R189.2 68.92,42.94 68.85,43.01 68.28,43.01 67.16,44.13 66.42,44.13 66.32,44.03 66.32,43.9 66.39,43.82 U6578.H8
CKDP: length 3.8
  TOP w0.071: U6578.G8 66.1,43.87 66.1,44.12 66.33,44.35 67.25,44.35 68.37,43.23 68.77,43.23 R190.2
CLK_32K_WLAN: length 32.6
  IN2 w0.058: v3(106.45,40.53) 106.42,40.5 v8(106.42,40.05) ; v3(117.1,46.49) 117.61,46.49 117.95,46.15 121.78,46.15 122.22,45.71 123.24,45.71 123.63,45.32 125.13,45.32 125.66,44.79 127.82,44.79 128.57,45.54 130.09,45.54 v3(130.54,45.98)
  IN4 w0.058: v3(130.54,45.98) 130.54,46.87 v5(131.43,47.76) ; v4(115.96,46.16) 116.77,46.16 v3(117.1,46.49) ; v4(107.76,40.49) 107.71,40.45 106.55,40.45 106.48,40.53 v3(106.45,40.53)
  IN5 w0.076: v4(115.96,46.16) 115.43,45.62 115.04,45.62 112.73,43.31 112.03,43.31 111.7,43.64 110.75,43.64 107.76,40.65 v4(107.76,40.49)
  BOTTOM w0.089: v5(131.43,47.76) 131.58,47.91 R90845.2
COMPASS_I2C_SCL: length 2.8
  TOP w0.089: U6575.A3 148.23,42.54 148.5,42.27 R90857.2
COMPASS_I2C_SCL_R: length 8.6
  TOP w0.089: v2(148.5,39.6) R90857.1 ; U6404.3 144.26,34.55 144.53,34.83 v2(145.25,34.83)
  IN2 w0.058: v2(145.25,34.83) 145.25,34.98 146.9,36.63 146.9,38.18 147.46,38.74 147.86,38.74 148.19,39.07 148.19,39.48 148.32,39.6 v2(148.5,39.6)
COMPASS_I2C_SDA: length 3.1
  TOP w0.089: U6575.B4 147.94,42.68 147.68,42.42 R90856.2
COMPASS_I2C_SDA_R: length 7.8
  TOP w0.089: v2(147.68,39.6) R90856.1
  IN2 w0.058: v2(147.68,39.6) 147.87,39.6 147.96,39.5 147.96,39.17 147.76,38.97 147.38,38.97 146.67,38.26 146.67,36.71 144.76,34.8 v2(144.76,34.14)
COMPASS_INT_L: length 3.5
  TOP w0.089: TP9084.1 148.6,47.35 148.6,44.66 148.51,44.57 U6575.D2
COMPASS_RDY_TP: length 3.6
  TOP w0.089: U6575.D4 147.94,44.58 147.51,45.01 TP9083.1
CON_EDP_BKLTEN_3V3: length 7.8
  TOP w0.089: v2(42.48,41.08) 42.28,41.08 42.12,40.93 42.12,40.54 41.82,40.24 Q705.3
  IN2 w0.058: v3(42.48,40.75) v2(42.48,41.08)
  IN4 w0.058: v3(42.48,40.75) 42.48,40.65 43.37,39.76 43.59,39.76 45.05,38.3 v5(45.05,37.8)
  BOTTOM w0.089: J15.23 v5(45.05,37.8)
CTP_I2C_SCL: length 19.5
  TOP w0.089: Q777.1 45.63,47.07 45.4,47.3 45.04,47.3 44.71,47.63 R90612.2 R91127.2 v2(44.61,46.94)
  IN2 w0.058: v3(44.61,46.59) v2(44.61,46.94)
  IN4 w0.058: v5(52,38.16) 51.84,38.31 51.84,39.09 51.24,39.7 51.24,44.56 49.61,46.18 44.46,46.18 44.31,46.34 44.31,46.56 44.36,46.62 44.59,46.62 v3(44.61,46.59)
  BOTTOM w0.089: v5(52,38.16) 51.93,38.08 51.93,37.09 52.05,36.97 J15.37
CTP_I2C_SDA: length 19.3
  TOP w0.089: Q776.1 42.75,47.81 42.83,47.73 43.37,47.73 43.46,47.63 R90614.2 R91126.2 v2(43.77,46.94)
  IN2 w0.058: v3(43.77,46.59) v2(43.77,46.94)
  IN4 w0.058: v3(43.77,46.59) 43.8,46.62 43.86,46.62 44.41,46.07 49.57,46.07 51.12,44.51 51.12,39.65 51.73,39.04 51.73,38.34 v5(51.54,38.16)
  BOTTOM w0.089: J15.36 51.55,36.97 51.75,37.17 51.75,37.95 v5(51.54,38.16)
D_GND: length 7350.8
  TOP w0.06: 89.56,47.2 87.37,45.01 v7(87.37,44.43) ; v7(82.18,44.27) 82.18,44.48 82.21,44.51 82.21,45.07 81.67,45.6 80.62,45.6 80.49,45.48 79.52,45.48 79.4,45.36 v7(79.22,45.36) 79.5,45.08 80.61,45.08 80.76,44.92 81.41,44.92 v7(81.58,44.75) ; v7(83.83,43.56) 84.07,43.79 84.07,46.02 83.04,47.04 78.51,47.04 78.24,47.31 78.24,51.46 79.13,52.36 80.15,52.36 v7(80.51,52.72) ; 92.39,41.39 90.87,41.39 v1(90.64,41.16) ; v8(80.96,44.26) 80.89,44.33 79.61,44.33 79.05,44.89 79.05,45.14 79,45.2 78.22,45.2 ; v1(93.79,39.55) 93.35,39.99 92.97,39.99 v1(92.77,40.19) ; v7(87.83,43.16) 88.08,43.41 88.08,44.49 89.81,46.22 91.5,46.22 92.64,47.35 92.64,48.81 v8(92.35,49.1) ; v7(86.33,44.63) 86.33,45.35 86.57,45.58 86.57,46.53 ; v7(86.02,56.13) 85.64,55.75 85.64,45.86 85.5,45.73 85.5,44.72 85.5,44.72 85.5,44.37 85.21,44.07 85.21,43.79 v7(85.43,43.56) ; 77.37,53.35 77.37,46.89 78.12,46.14 82.73,46.14 83.14,45.74 83.14,44.6 v7(83.22,44.51)
  TOP w0.075: U1001.R26 90.87,38.6 91.26,38.6 ; v1(84.5,47.04) 84.5,47.01 84.6,46.79 84.6,44.91 v7(84.69,44.82) ; v7(90.64,37.16) 90.9,37.42 92.21,37.42 92.33,37.3 ; 91.55,37.9 91.52,37.9 v7(91.48,37.94)
  TOP w0.089: SH8101.2 109.38,34.78 109.15,35.01 v2(109.08,35.01) ; v2(69.73,45.32) 69.73,43.82 v2(69.76,43.8) ; v2(69.73,45.32) 68.03,45.32 67.85,45.5 66.23,45.5 v1(65.24,44.51) ; v2(69.73,45.32) 69.73,46.66 69.55,46.84 68.69,46.84 68.23,46.39 66.07,46.39 64.24,44.56 v1(64.14,44.56) ; 91.26,38.6 91.37,38.49 92.52,38.49 92.55,38.46 93,38.46 93.15,38.31 93.15,38.29 93.23,38.21 93.23,37.65 v1(93.15,37.57) ; 11.93,21.95 11.68,22.21 11.12,22.21 10.61,22.71 v2(9.73,22.71) 9.51,22.71 8.7,23.53 7.86,23.53 7.63,23.76 v1(7.63,24.54) 7.63,25.3 7.88,25.56 v1(8.49,25.56) ; 11.93,21.95 11.79,21.81 11.79,20.09 v2(11.99,19.9) ; 11.93,21.95 13.52,21.95 v1(13.67,21.8) ; 70.71,40.95 70.8,40.86 70.8,39.96 v1(70.47,39.63) 69.93,39.1 68.5,39.1 67.01,40.58 67.01,41.51 v1(66.89,41.64) ; 70.71,40.95 70.72,40.95 70.98,41.2 70.98,42.02 70.72,42.27 69.91,42.27 v2(69.78,42.4) ; 70.71,40.95 70.14,40.95 v1(70.09,41) 70.01,40.93 69.78,40.93 69.6,40.75 68.18,40.75 67.8,41.13 67.8,41.93 v2(67.01,42.73) ; v1(69.78,24.54) 69.78,24.49 69.88,24.39 v1(69.88,24.03) 69.88,23.98 69.71,23.81 v1(68.89,23.81) 68.89,23.86 68.72,24.03 v1(68.72,24.69) ; v2(69.76,43.8) 68.26,43.8 67.37,44.68 v1(66.68,44.68) ; v2(69.76,43.8) 69.78,43.77 v2(69.78,42.4) ; SH2001.2 105.44,34.91 v2(105.39,34.96) ; v2(23.4,30.33) 23.4,30.51 23.91,31.02 23.91,31.69 C175.2 24.72,32.5 v1(24.72,33.41) 24.72,33.76 25,34.04 25,35.31 24.49,35.82 24.49,38.21 24.24,38.46 v1(23.99,38.46) v1(23.22,38.46) ; v2(34.4,17.79) 34.78,17.79 35.03,18.04 35.03,21.72 34.78,21.98 v2(34.65,21.98) 34.65,22.1 35.03,22.49 v2(35.03,23.96) ; v2(10.4,17.71) 9.3,16.62 9.3,13.47 9.63,13.14 v2(9.71,13.14) 10.6,13.14 10.98,13.52 v2(10.98,13.93) 10.98,15.17 10.4,15.75 v1(10.4,16.31) ; C10374.2 115.42,34.44 115.25,34.27 115.25,33.99 115.43,33.81 115.77,33.81 116.31,34.36 116.31,35.19 115.98,35.52 v2(115.42,35.52) ; 19.82,39.63 19.82,38.94 v2(19.87,38.89) 20.28,38.48 20.28,35.83 v2(19.89,35.44) 19.89,35.09 20.28,34.7 20.28,33.97 v2(20.33,33.92) 20.28,33.86 v2(20.28,32.7) ; 19.82,39.63 19.6,39.86 v2(19.36,39.86) ; 19.82,39.63 20.15,39.63 20.23,39.55 20.91,39.55 v2(21.01,39.45) ; v1(22.84,26.55) 22.84,27.57 22.64,27.77 22.16,27.77 22.13,27.79 v2(22.11,27.79) ; v1(22.84,26.55) 23.1,26.3 23.86,26.3 v6(24.85,25.3) ; v1(22.84,26.55) 22.59,26.3 22.03,26.3 v1(21.95,26.22) 21.88,26.3 21.83,26.3 21.8,26.32 19.19,26.32 19.01,26.14 v2(18.65,26.14) 18.13,26.14 18.02,26.26 18.02,27.34 18.09,27.41 v2(18.09,27.69) ; v1(61.83,38.31) 61.9,38.31 61.98,38.22 61.98,35.39 62.29,35.08 62.29,34.32 63.41,33.2 65.85,33.2 v1(66,33.05) 66.2,33.25 67.28,33.25 67.34,33.32 70.37,33.32 70.58,33.1 72.98,33.1 v1(73.31,32.77) 73.57,32.52 73.57,22.04 v1(73.44,21.91) 73.44,21.47 v1(74.53,20.38) 75.73,19.18 v1(75.73,15.37) 75.9,15.2 v6(76.54,15.2) 76.56,15.17 77.22,15.17 v6(77.25,15.2) 77.28,15.17 77.94,15.17 v6(77.96,15.2) v6(78.67,15.2) 78.67,16.03 78.49,16.21 77.66,16.21 77.33,15.89 76.43,15.89 v1(76.31,16.01) 76.23,16.08 76.23,19.72 v1(74.89,21.06) 74.07,21.88 74.07,22.66 ; v1(21.5,44.56) 21.5,45.17 20.82,45.84 20.11,45.84 18.93,47.02 v1(18.93,47.3) 18.65,47.3 18.14,47.81 18.14,50.15 17.37,50.92 15.01,50.92 v1(14.66,50.58) 14.64,50.6 12.1,50.6 v1(11.13,51.57) 11.03,51.67 10.09,51.67 9.97,51.55 D2741.3 9.97,50.57 10.32,50.22 11.26,50.22 11.74,49.74 14.33,49.74 14.51,49.56 15.07,49.56 15.2,49.43 16.92,49.43 17.23,49.13 17.23,47.68 17.64,47.28 v1(17.64,47.05) 19.6,45.08 20.06,45.08 20.15,44.99 v1(20.15,44.53) ; v1(23.22,38.46) 22.92,38.46 22.82,38.36 22.82,37.75 v6(23.1,37.47) 23.1,37.25 v2(22.69,36.84) 22.69,35.14 v6(22.82,35.01) 22.87,34.96 22.87,31.76 22.61,31.5 v2(22.28,31.5) ; v1(23.22,38.46) 23.22,39.17 22.94,39.45 v2(21.01,39.45) ; v1(91.85,25.1) 92.31,25.1 93.07,24.34 96.5,24.34 96.83,24.67 ; v2(93.29,44.01) 93.24,44.01 93.07,43.85 C4101.1 ; R2206.2 v2(105.01,29.71) ; v2(21.01,39.45) 21.14,39.32 21.14,37.14 21.22,37.06 v1(21.22,36.84) 21.22,35.92 21.87,35.26 21.87,33.99 v2(21.8,33.92) 21.8,33.38 v2(21.14,32.72) ; v1(64.8,28.86) 64.63,28.69 64.22,28.69 63.75,28.21 v6(63.44,28.21) 63.09,27.87 63.09,26.15 63.18,26.07 v1(63.18,26.04) 63.19,26.04 63.28,25.95 63.28,24.44 62.99,24.15 62.61,24.15 v1(62.59,24.14) ; v2(69.78,42.4) 69.66,42.27 68.54,42.27 67.12,43.69 v2(66.89,43.69) ; 91.55,37.9 91.6,37.85 92.69,37.85 92.76,37.78 92.95,37.78 v1(93.15,37.57) ; v1(71.26,26.12) 71.26,25.67 71.39,25.53 71.39,24.17 71.1,23.88 71.1,23.4 71.28,23.22 72.17,23.22 72.47,23.53 72.47,24.06 v1(72.37,24.17) 72.37,24.17 72.12,24.42 72.12,26.93 71.92,27.13 v1(71.92,27.16) ; 78.22,45.2 78.18,45.2 78.09,45.11 v2(78.09,44.76) ; v1(13.67,21.8) 13.47,21.6 v2(13.47,19.87) ; v1(13.67,21.8) 14.18,21.8 14.49,21.49 14.99,21.49 15.2,21.7 15.2,22.21 14.74,22.66 12.4,22.66 12.3,22.76 v2(12.3,23.02) v2(11.54,23.02) 11.33,23.02 11.13,23.22 11.13,23.5 10.93,23.7 9.84,23.7 v1(9.61,23.93) 9.61,24.14 9.79,24.31 v1(10.19,24.31) ; v1(12.96,54.31) 12.86,54.31 12.58,54.03 12.58,52.93 12.7,52.81 v2(13.57,52.81) 15.32,52.81 v1(15.6,53.09) ; v1(12.96,54.31) 12.96,55.33 15.2,57.56 HOLE11.1 14.25,58.95 v2(7.93,58.95) ; v1(12.96,54.31) 16.42,54.31 16.82,53.9 16.82,53.11 v2(16.49,52.78) 16.18,53.09 v1(15.6,53.09) ; 63.43,22.94 63.76,22.61 63.76,20.48 65.2,19.04 v1(65.2,18.97) 65.22,18.94 71.4,18.94 v1(71.51,18.83) 74.02,18.83 74.61,18.24 74.61,11.84 v1(74.44,11.68) 73.92,11.15 73.92,9.76 74.2,9.48 74.82,9.48 75.23,9.88 75.23,10.68 v1(75.37,10.83) 75.37,18.65 74.23,19.79 v1(71.71,19.79) 65.57,19.79 64.7,20.66 v1(64.7,21.01) 64.7,21.46 v1(65.21,21.97) 64.78,22.4 64.78,25.96 v1(65.06,26.24) ; 63.43,22.94 v1(63.41,22.97) 62.92,22.97 62.59,23.3 v1(62.59,24.14) ; 63.43,22.94 63.76,22.94 64.02,23.2 64.02,26.75 v1(64.42,27.16) ; v6(14.74,47.94) 15.78,47.94 16.11,47.61 16.11,38.66 v1(15.55,38.11) v1(13.78,36.33) 13.78,35.24 15.22,33.79 ESD7508.1 v2(15.22,33) 15.22,32.49 v1(14.99,32.26) 14.99,30.64 15.29,30.34 15.29,28.7 14.73,28.14 C9058.2 ; v2(21.45,42.17) 21.47,42.2 22.39,42.2 22.69,41.89 22.69,41.23 22.33,40.87 v2(21.78,40.87) 20.66,40.87 20.15,41.38 v2(20.15,42.14) ; C7210.2 94.11,43.06 94.83,43.06 95.26,42.63 v2(95.26,42.53) 95.11,42.37 94.75,42.37 94.53,42.15 v2(94.53,41.92) 94.5,41.89 93.84,41.89 93.34,41.39 92.39,41.39 ; 10.93,49.43 14.08,49.43 14.38,49.13 15.6,49.13 16.72,48.01 16.72,42.53 v2(17.05,42.2) 17.05,42.06 16.72,41.73 16.72,38.13 v1(14.79,36.2) 14.38,35.79 14.38,35.49 16.01,33.86 v1(16.01,32.26) 15.71,31.96 15.71,30.84 v1(16.01,30.54) 16.01,30.23 R91282.1 16.03,29.95 15.89,29.81 15.89,28.57 15.96,28.5 ESD6206.1 ; v1(93.15,37.57) 93.23,37.57 93.43,37.37 93.43,37.04 93.02,36.63 v2(93.02,36.53) 93.02,36.54 92.91,36.54 92.84,36.61 C6701.2 92.64,36.67 92.33,36.97 92.33,37.3 ; v1(62.59,24.14) 62.21,24.14 62.06,24.29 62.06,25.76 v1(62.25,25.95) 62.36,26.06 62.36,27.67 62.04,28 62.04,29.32 62.92,30.2 v6(63.15,30.2) 63.47,30.2 63.66,30 v1(64.27,30) v1(65.85,30) ; v6(8.11,51.06) 8.24,51.19 v2(8.24,52.36) ; v2(29.07,15.6) 29.07,15.37 29.32,15.12 30.72,15.12 31,15.4 v1(31,15.58) ; v2(65.16,40.71) 65.16,40.68 65.18,40.66 65.21,40.66 65.26,40.6 65.26,40.01 65.39,39.88 66.25,39.88 66.91,39.23 66.91,38.91 66.7,38.69 v1(66.4,38.69) 66.4,38.49 66.02,38.11 66.02,35.17 65.93,35.08 64.09,35.08 63.86,34.85 63.86,34.32 64.44,33.75 67.02,33.75 67.29,34.02 v2(67.93,34.02) 68.76,34.02 v2(68.82,33.96) 68.96,33.81 70.65,33.81 70.87,33.58 73.54,33.58 74.23,32.9 v1(74.23,32.65) ; v1(15.6,53.09) 15.6,52.97 15.98,52.58 15.98,51.87 15.81,51.7 15.27,51.7 15.17,51.8 v1(14.87,51.8) 14.79,51.8 14.46,51.47 12.61,51.47 v1(12.1,51.97) 12.1,52 11.75,52.35 11.75,55.42 v1(11.63,55.54) 11.63,55.64 10.7,56.57 10.34,56.57 C10448.1 10.19,56.72 10.19,57.7 9.79,58.11 v2(9.38,58.11) ; 117.2,24.44 116.12,25.52 113.12,25.52 112.33,26.32 109.71,26.32 ; C4203.2 91.5,44.99 91.16,44.65 90.8,44.65 90.24,44.09 v7(90.24,43.56) ; v1(45.7,6.48) 46.08,6.1 46.08,4.45 46.39,4.15 v1(46.85,4.15) 47.94,4.15 48.88,5.09 50.4,5.09 50.66,4.83 50.66,4.2 v1(50.53,4.07) 50.02,4.07 49,3.05 48.07,3.05 v1(48.01,3.1) 47.96,3.05 44.18,3.05 43.98,3.26 43.98,4.96 44,4.98 44,5.26 43.67,5.59 v1(43.67,6.48) ; SH8102.2 108.94,32.66 v2(108.82,32.77) ; v1(111.96,32.38) 112.3,32.38 112.57,32.1 112.57,29.6 112.48,29.51 109.01,29.51 108.72,29.8 108.72,32.16 108.77,32.21 108.77,32.72 v2(108.82,32.77) ; v2(108.82,32.77) 108.14,32.77 108.06,32.86 SH6102.1 ; R91156.1 18.06,39.86 17.94,39.73 17.94,36.79 v1(18.02,36.71) 18.02,35.97 v2(18.45,35.54) 18.45,35.26 19.39,34.32 v2(19.39,32.65) ; v1(114.33,10.12) 114.33,10.24 114.41,10.32 114.41,11.33 v1(114.81,11.74) 115.75,12.67 115.75,14.05 v1(115.9,14.2) 116.12,14.41 116.12,15 116.29,15.17 v1(116.29,15.42) ; v1(114.33,10.12) 114.59,9.86 115.73,9.86 v1(115.98,10.12) 115.88,10.22 115.88,10.6 117.31,12.02 v1(117.31,12.04) 117.31,12.35 117.2,12.46 117.2,13.37 117.57,13.74 117.57,14.39 117.68,14.5 117.68,15.13 117.51,15.3 v1(117.33,15.3) 117.33,15.58 117.15,15.75 116.75,15.75 116.42,15.42 v1(116.29,15.42) ; v1(114.33,10.12) 114.21,10.12 113.47,10.85 113.47,11.26 v1(113.55,11.33) 113.55,11.56 115.07,13.09 115.07,14.92 115.71,15.55 116.16,15.55 v1(116.29,15.42) ; v2(20.18,19.77) 18.19,19.77 18.04,19.92 18.04,23.5 v1(19.7,25.15) ; CON7101.A12 8.74,53.45 8.85,53.35 10.14,53.35 U2.3 ; v1(63.51,40.14) 63.38,40.01 62.9,40.01 62.11,39.23 C10671.2 61.76,39 61.65,39.1 60.37,39.1 60.24,39.22 60.24,43.6 60.46,43.82 61.2,43.82 61.93,43.08 62.47,43.08 v1(62.59,43.21) ; 8.24,50.93 8.19,50.98 ; v2(105.95,27.13) 105.95,26.92 105.62,26.58 105.62,25.13 106.29,24.45 107.74,24.45 108.16,24.87 111.68,24.87 112.52,24.03
  TOP w0.127: v2(121.14,31.83) 120.86,31.83 120.58,32.1 119.95,32.1 v2(119.48,31.63)
  TOP w0.15: U1001.J3 U1001.H2 v7(81.43,41.56) ; v8(89.43,43.56) U1001.C24 v7(90.24,43.56) ; v8(89.43,37.56) 89.03,37.56 v8(88.64,37.96) ; v1(91.88,42.13) 91.92,42.17 92.57,42.17 92.67,42.27 v1(92.82,42.27) ; v7(85.03,42.76) v7(84.64,43.16) ; v7(83.43,40.76) v7(82.64,41.56) ; v8(85.83,42.36) v7(85.43,42.76) ; v7(90.64,40.76) U1001.K25 ; v7(84.24,43.16) v7(83.83,43.56) ; v7(86.64,42.76) v7(86.24,42.36) ; v1(89.83,41.16) v8(89.43,40.76) U1001.K24
  TOP w0.152: v7(90.64,40.76) U1001.K27 91.47,40.36 92.11,41 93.53,41 93.73,40.8 v1(93.73,40.7) 93.96,40.47 R1011.1 94.34,39.73 v1(94.39,39.68) 94.45,39.68 94.65,39.88 R1004.1 v1(95.03,39.93) 95.03,41.13 94.53,41.63 v2(94.53,41.92)
  TOP w0.178: U6522.6 114.5,54.09 114.59,54.18 v1(114.59,54.31) ; v2(115.68,56.65) 115.59,56.65 115.3,56.35 U6522.13
  TOP w0.2: U2001.H8 U2001.H9 U2001.G9 ; U2001.H8 U2001.H7 U2001.G7 ; U2001.H8 U2001.G8 ; U2001.G9 U2001.F9 v7(106.02,38.45) ; U2001.G9 U2001.G8 ; v8(105.62,38.45) v7(106.02,38.45) ; v7(106.02,38.45) v8(106.02,38.05) U2001.G7 ; v7(106.02,38.45) U2001.G8 ; v7(86.64,34.36) v8(86.24,34.36) v8(86.24,33.96) v1(86.24,33.56) v1(86.24,33.16) ; v7(82.24,41.96) v7(82.24,41.56) ; v7(82.24,41.96) v7(81.83,41.96) ; v7(82.24,41.96) v7(82.64,41.96) ; v7(82.24,41.56) v7(82.64,41.56) v7(82.64,41.96) ; v7(82.24,41.56) v8(81.83,41.56) ; v7(81.43,42.36) v8(81.83,42.36) U1001.E4 v7(81.83,41.96) ; v7(81.43,42.36) v7(81.03,42.36) ; v7(81.43,42.36) v8(81.43,41.96) ; v7(81.43,42.36) v8(81.43,42.76) v8(81.43,43.16) ; U1001.AG8 v1(83.43,33.96) ; U1001.AG8 v7(83.83,33.56) v7(83.83,33.16) ; U1001.AG8 U1001.AH8 v7(83.83,33.16) ; v1(83.43,33.96) v7(83.43,34.76) ; v1(83.43,33.96) U1001.AF9 ; v8(81.43,41.96) v7(81.83,41.96) ; v8(81.43,41.96) v7(81.43,41.56) v8(81.83,41.56) ; v7(81.83,41.96) v8(81.83,41.56) ; U2001.G8 U2001.G7 ; U1001.K25 U1001.K24 ; v8(87.03,39.16) v8(87.43,38.76) v8(87.03,38.36) ; v8(84.64,41.96) v8(84.24,41.96) v8(83.83,41.96) v7(83.43,41.96) v7(83.03,41.96) v7(82.64,41.96) ; v7(83.83,33.16) v7(83.83,32.76) ; v7(86.24,42.36) v8(85.83,42.36) ; v7(87.83,43.16) v7(87.43,43.16) ; v1(89.83,41.16) v1(90.24,41.16) v1(90.64,41.16) v7(90.64,40.76) ; v8(87.43,39.56) v8(87.03,39.96) v8(87.43,40.36) v8(87.03,40.76) ; v7(84.64,43.16) v7(84.24,43.16) ; v8(87.43,41.96) v8(87.03,41.96) ; v7(85.43,42.76) v7(85.03,42.76)
  TOP w0.203: U6575.E1 149.08,44.72 v2(149.08,47.07) ; C10350.2 130.59,54.08 v2(130.87,54.36) ; R91156.1 R91157.1 v2(19.36,39.86) ; v6(146.61,15.48) 145.88,16.21 C10505.2 ; v2(59.42,16.8) 60.1,16.8 C10370.2 ; C10604.2 17.82,42.2 v2(17.05,42.2) ; v2(64.86,41.82) v2(64.86,42.22) ; v2(64.86,42.22) v2(65.26,42.22) ; v2(64.86,42.22) v2(64.86,42.62) ; v2(146.34,47.4) 146.34,45.18 U6575.C5 ; v2(105.49,29.04) 105.49,28.73 105.71,28.52 v2(106.03,28.52) ; v6(129.65,17.91) U6528.11 129.65,19.51 129.97,19.83 129.97,20.34 129.75,20.55 v2(129.52,20.55) ; v1(61.83,38.31) 61.83,38.46 62.11,38.74 C10671.2 ; v2(22.72,16.8) 22.72,15.91 v2(22.41,15.6) 22.23,15.42 21.47,15.42 21.42,15.48 v2(20.99,15.48) 20.87,15.48 20.68,15.3 v2(20.68,14.38) 20.56,14.26 19.01,14.26 Y1.2 17.31,15.21 17.13,15.4 17.13,18.24 17.33,18.45 v2(17.61,18.45) v2(18.55,18.45) 20.48,18.45 20.99,17.94 v2(20.99,17.05) 21.42,17.05 21.73,17.35 v1(21.73,18.04) ; U6559.48 138.5,13.68 v6(138.92,14.1) ; C10606.2 110.95,32.9 v2(111.21,33.15) 110.95,33.41 C10483.2 110.95,34.33 110.88,34.4 C10689.2 111.36,34.58 v2(111.36,34.57) ; v2(67.93,34.02) 67.85,34.09 C240.1 ; v2(88.15,28.77) C7405.1 ; v1(19.01,44.43) 19.4,44.04 U6555.9 ; v2(105.29,57.95) 105.29,58.25 U18.J5 ; v7(89.83,39.96) U1001.K24 ; C10552.2 115.27,41.59 v2(115.62,41.59) ; v1(106.37,30.96) 106.41,30.92 R2205.2 ; v2(148.14,47.58) 148.04,47.48 148.04,45.44 148.23,45.25 U6575.E3 ; v1(90.31,28.21) 90.15,28.37 C7407.1
  TOP w0.254: v2(31.45,45.12) R91029.2 ; U18.A6 101.28,58.86 100.92,59.22 100.92,59.39 v2(100.74,59.57) ; U5.B4 v2(38.01,21.59) ; v2(119.46,32.57) 119.31,32.72 C10452.2 ; v2(98.48,9.12) 98.42,9.06 Q55.1 ; U6563.22 v2(30.01,34.9) ; C10412.1 26.48,42.84 26.48,42.32 v2(26.58,42.22) ; v2(56.12,36.84) 56.5,36.84 57.13,37.46 Q791.1 ; v2(134.22,17.41) 134,17.63 C10380.1 ; v2(121.06,35.41) 120.97,35.32 R405.2 ; C10458.2 65.79,32.67 66,32.87 v1(66,33.05) ; C2142.2 v2(111.51,44.62) ; R91231.1 66.66,34.8 v1(66.78,34.68) ; R91251.2 30.2,48.27 30.72,47.76 v2(30.72,47.63) ; v6(8.11,51.06) 8.19,50.98 D2741.3 ; CON7101.A12 7.93,53.3 8.36,52.87 8.36,52.48 v2(8.24,52.36) ; R90782.2 v2(9.73,22.71) ; v2(31.21,47.65) Q795.1 ; v2(124.82,39.05) 124.05,39.05 C533.1
  TOP w0.305: v6(70.37,9.41) 70.37,9.79 70.71,10.14 v7(71.07,10.14)
  TOP w0.508: v6(120.38,27.06) 120.4,27.06 120.85,26.61 C10666.2
  IN1 w0.06: 86.03,42.16 86.03,43.36 ; 86.03,42.16 85.64,42.16 ; 86.03,42.16 86.83,42.16 ; 88.03,43.16 88.03,41.76 ; 88.03,41.76 87.64,41.76 ; 88.03,41.76 88.43,41.76 ; v7(88.64,43.96) 88.73,43.96 88.83,43.86 88.83,42.76 ; 85.64,42.16 85.64,43.56 ; 85.64,42.16 85.24,42.16 ; 88.43,43.16 88.43,41.76 ; 88.43,41.76 88.77,41.76 88.83,41.82 88.83,42.16 ; 83.63,42.16 83.64,42.16 83.64,42.55 83.64,42.56 ; 83.63,42.16 82.84,42.16 ; 83.63,42.16 84.83,42.16 ; v2(95.31,38.56) 95.06,38.82 94.39,38.82 93.79,39.43 v1(93.79,39.55) 93.96,39.55 94.22,39.3 94.72,39.3 94.85,39.17 95.54,39.17 95.77,38.94 95.77,38.79 ; v2(109.08,35.01) 109.1,34.99 109.1,33.05 v2(108.82,32.77) ; 83.64,42.56 83.64,42.57 83.64,42.95 83.65,42.96 ; 83.64,42.56 88.64,42.56 v7(88.64,42.76) 88.83,42.76 ; 83.64,42.56 81.43,42.56 ; 108.97,30.54 108.78,30.54 108.61,30.71 108.61,30.8 108.36,31.04 108.36,32.06 108.14,32.29 108.14,33.08 108.47,33.41 v2(108.47,33.82) ; 87.24,42.16 86.83,42.16 ; 87.24,42.16 87.24,43.16 ; 87.24,42.16 88.83,42.16 ; 87.24,42.16 87.24,41.76 87.23,41.76 ; 86.83,42.16 86.83,43.16 ; 86.83,42.16 86.83,41.83 86.9,41.76 87.03,41.76 ; 85.24,42.16 85.24,43.56 ; 85.24,42.16 84.83,42.16 ; 88.83,42.76 88.83,42.16 ; v1(94.39,39.68) 94.47,39.6 94.83,39.6 94.95,39.48 95.66,39.48 96.3,38.84 96.3,36.49 v2(96.24,36.43) 96.24,36.2 ; 83.65,42.96 81.64,42.96 v8(81.43,42.76) ; 83.65,42.96 86.64,42.96 ; v7(82.64,41.96) 82.43,42.16 82.43,43.56 ; 81.63,41.96 81.63,43.56 ; 89.24,39.86 89.24,40.06 89.34,40.16 89.54,40.16 89.8,40.42 92.03,40.42 92.95,41.33 ; 89.24,39.86 89.14,39.76 88.78,39.76 88.64,39.62 v2(88.64,39.16) 88.84,39.36 89.52,39.36 89.64,39.48 89.64,39.68 89.83,39.88 v7(89.83,39.96) ; 89.24,39.86 89.33,39.76 89.54,39.76 89.74,39.96 v7(89.83,39.96) ; 87.03,41.76 v8(87.03,41.96) ; 87.03,41.76 87.23,41.76 ; v7(89.83,39.96) 90.03,40.16 92.18,40.16 93.1,41.08 93.86,41.08 94.19,40.75 95,40.75 v2(95.16,40.9) ; 82.03,41.96 82.03,43.56 ; 82.84,42.16 82.83,42.16 82.83,43.56 ; 82.84,42.16 81.43,42.16 ; 87.23,41.76 87.64,41.76 ; 95.51,40.24 95.28,40.47 93.96,40.47 v1(93.73,40.7) 93.12,40.7 92.77,40.34 v1(92.77,40.19) 92.9,40.06 94.91,40.06 v1(95.03,39.93) ; 87.64,41.76 87.64,43.16 ; 92.59,38.56 92.03,38.56 ; 83.24,41.96 83.24,43.56 ; 84.43,41.96 84.43,43.56 ; 84.03,43.56 84.03,41.96 ; 84.83,42.16 84.83,43.56
  IN1 w0.075: 81.24,47.79 81.29,47.84 81.29,48.17
  IN1 w0.076: 95.51,40.24 95.92,40.24 97.04,39.12 97.04,36.79 97.37,36.46 v2(97.37,36.35) 97.39,36.33 97.39,35.59 98.2,34.78 98.2,32.7 99.32,31.58 v1(99.32,31.45) 100.14,30.64 100.26,30.64 101.38,29.52 v1(101.43,29.52) v1(101.76,29.52) v1(102.45,29.52) v1(102.78,29.52) v2(103.46,29.52) 103.79,29.52 104.22,29.95 104.22,30.08 104.89,30.75 105.01,30.75 105.82,31.57 105.82,31.76 106.03,31.96 106.03,33.1 v2(105.65,33.48) ; v2(95.44,22.18) 95.44,21.01 95.28,20.86 93.94,20.86 92.36,22.43 92.36,23.3 90.97,24.69 90.55,24.69 90.08,25.17 90.08,27.12 90.62,27.66 90.62,28.01 90.42,28.21 v1(90.31,28.21) 90.22,28.21 89.72,27.72 89.72,24.95 90.53,24.14 90.91,24.14 91.91,23.15 91.91,22.13 93.63,20.4 95.44,20.4 96.25,21.22 96.25,22.1 95.99,22.36 95.61,22.36 v2(95.44,22.18) ; v2(95.44,22.18) 95.36,22.26 93.45,22.26 93.02,22.69 93.02,23.68 92.39,24.32 92.39,24.57 v1(91.85,25.1) ; v1(115.98,10.12) 115.98,10.22 115.58,10.62 114.66,10.62 114.33,10.29 v1(114.33,10.12) 114.33,9.71 112.69,8.07 92.88,8.07 92.12,8.83 88.32,8.83 85.4,11.75 79.82,11.75 74.43,6.37 74.43,6.15 72.84,4.57 69.59,4.57 69.48,4.45 68.21,4.45 v2(67.72,4.93) 67.7,4.96 67.7,5.34 67.9,5.54 68.84,5.54 69.15,5.24 72.32,5.24 79.51,12.43 85.68,12.43 88.6,9.51 92.41,9.51 93.18,8.74 98.1,8.74 v2(98.48,9.12) 98.87,8.74 108.54,8.74 v6(109.33,9.53) ; v2(95.16,40.9) 94.85,41.2 94.32,41.2 94.14,41.38 93,41.38 92.95,41.33 ; v2(105.95,27.13) 104.99,27.13 104.58,26.73 v1(101.76,26.73) 100.16,26.73 v1(99.73,27.16) 99.63,27.16 96.73,30.05 96.73,30.7 v2(96.41,31.02) 95.92,31.51 95.92,33.13 v2(95.61,33.43) 95.77,33.58 95.77,33.92 94.85,34.83 94.85,35.34 v1(94.78,35.41) 94.78,35.74 94.93,35.9 94.93,36.35 v2(94.6,36.68) ; v2(105.49,29.04) 105.39,28.94 105.14,28.94 104.28,28.07 v1(103.18,28.07) 100.92,28.07 v1(100.59,28.4) 100.47,28.4 99.83,29.04 99.83,29.17 97.87,31.12 97.87,31.36 97.06,32.17 97.06,34.27 96.24,35.09 96.24,36.2 ; v2(105.49,29.04) 105.67,29.04 105.7,29.07 105.97,29.07 106.22,29.31 106.22,29.58 106.03,29.77 v2(106.03,29.88) 105.89,29.88 105.57,29.56 105.57,29.37 105.49,29.29 v2(105.49,29.04) ; v1(106.37,30.96) 106.32,30.96 105.2,29.83 105.14,29.83 v2(105.01,29.71) 105.01,29.5 104.15,28.63 v1(102.37,28.63) v1(101.86,28.63) 101.76,28.73 101.1,28.73 100.19,29.65 100.01,29.65 98.43,31.22 v1(98.43,31.35) 98.43,31.48 97.52,32.39 97.52,34.47 96.71,35.29 96.71,36.51 96.6,36.61 96.6,38.94 95.77,39.78 95.19,39.78 v1(95.03,39.93) ; v2(106.64,29.83) 106.68,29.79 106.68,29.12 106.16,28.61 106.11,28.61 v2(106.03,28.52) 105.99,28.48 105.34,28.48 104.38,27.51 v1(102.68,27.51) 100.57,27.51 98.51,29.57 98.51,29.75 97.42,30.84 97.42,31.15 96.6,31.96 96.6,34.07 95.66,35.01 v1(95.66,35.49) 95.66,36.03 v2(95.68,36.05) 95.68,36.72 95.61,36.79 95.61,37.07 95.92,37.37 v2(95.92,37.45) 96.01,37.53 96.01,38.55 95.77,38.79 95.54,38.56 v2(95.31,38.56) ; v2(33.19,16.25) 33.79,16.85 v2(33.79,18.83) v2(33.79,20.63) 33.79,21.27 34.5,21.98 v2(34.65,21.98) 34.65,22.37 34.39,22.64 34.17,22.64 33.79,23.02 v2(33.79,23.37) 33.79,23.78 34.02,24.01 34.99,24.01 v2(35.03,23.96) 35.03,23.91 v2(36.38,22.56) 37.04,22.56 v2(38.01,21.59) 38.01,21.55 37.69,21.23 37.69,20.58 v2(37.99,20.29) 37.99,18.36 v2(38.01,18.33) 38.01,18.22 37.69,17.9 37.69,17.36 v2(38.01,17.04) 38.01,16.88 37.17,16.03 36.79,16.03 v2(36.18,15.42) 34.7,15.42 v2(34.16,14.88) 33.43,14.15 v2(31.58,14.15) 29.85,14.15 v2(29.68,14.33) 29.07,14.94 v2(29.07,15.6) 29.07,16.01 29.17,16.11 30.84,16.11 31,15.96 v1(31,15.58) 31.07,15.5 32.44,15.5 v2(33.19,16.25) ; v2(112.78,50.33) 111.86,50.33 v2(111.82,50.37) 111.6,50.15 v2(111.26,50.15) 111.1,50 105.8,50 105.3,50.49 103.25,50.49 103.03,50.27 v2(102.89,50.27) 102.89,50.15 102.37,49.63 100.98,49.63 100.76,49.86 100.76,50.2 100.56,50.4 100.16,50.4 99.96,50.2 99.96,48.65 100.19,48.42 100.49,48.42 101.1,49.02 102.75,49.02 102.99,49.27 v2(103.02,49.27) 103.02,49.3 103.61,49.88 105,49.88 105.82,49.06 106.07,49.31 113.16,49.31 113.62,49.76 115.96,49.76 v1(117.6,48.13) 118.22,47.5 118.22,46.23 118.6,45.85 118.6,45.22 118.98,44.84 119.87,44.84 120,44.96 v2(120,45.22) 120,45.6 118.85,46.74 118.85,48.04 118.09,48.81 118.09,48.94 v1(117.86,49.18) 117.65,49.39 117.51,49.39 116.42,50.48 113.46,50.48 113.31,50.33 v2(112.78,50.33) ; 101.97,56.45 100.41,56.45 99.6,57.26 99.6,58.83 100.34,59.57 v2(100.74,59.57) 102.14,59.57 102.5,59.21 102.5,57.96 v2(102.39,57.86) 102.39,57.28 102.14,57.03 102.14,56.62 101.97,56.45
  IN1 w0.15: 85.64,43.56 85.84,43.56 86.24,43.16 86.64,43.16
  IN1 w0.2: v8(83.83,41.96) v7(83.43,41.96) v7(83.03,41.96) ; 85.64,43.56 v7(85.43,43.56) v7(83.83,43.56) 83.24,43.56 ; 83.22,43.57 83.24,43.56 ; 83.24,43.56 81.55,43.56 81.43,43.44 v8(81.43,43.16) ; v7(88.45,49.1) 88.81,49.45 v8(89.06,49.45) ; 87.37,43.16 86.64,43.16 v7(86.64,42.76) ; 87.37,43.16 v7(87.43,43.16) v7(87.83,43.16) 88.64,43.16 ; 87.37,43.16 v7(87.37,44.43) ; v7(82.64,41.96) v7(82.24,41.96) v7(81.83,41.96) v8(81.43,41.96) v7(81.43,42.36) ; v7(89.03,43.16) 89.1,43.22 89.1,43.61 89.27,43.79 v8(89.27,43.83) ; v7(88.64,42.76) 88.64,43.16 ; 88.64,43.16 v7(88.64,43.56) v7(88.64,43.96) ; v8(84.24,41.96) v8(84.64,41.96)
  IN1 w0.203: v7(82.64,41.96) v7(82.64,41.56) ; v7(81.43,41.56) v8(81.83,41.56) v7(82.24,41.56) ; v8(88.64,36.39) v8(88.64,36.76)
  IN1 w0.254: v2(9.73,22.71) 9.73,23.05 v1(11.36,24.68) v1(11.36,25.08) 11.57,25.08 11.74,25.25 11.74,25.66 11.52,25.88 v1(11.36,25.88)
  IN2 w0.058: 95.99,21.24 97.04,20.2 99.91,20.2 100.04,20.06 v6(100.14,20.06) 100.33,20.06 100.47,20.2 102.09,20.2 102.29,20.4 104.22,20.4 106.36,22.54 107.47,22.54 HOLE15.1 113.64,16.37 v3(113.64,15.98) 113.64,14.95 v3(113.44,14.76) 113.44,14.62 115.3,12.76 115.39,12.76 v3(115.68,12.47) ; 95.99,21.24 95.74,21.49 95.72,21.49 95.44,21.78 v2(95.44,22.18) ; 95.99,21.24 95.79,21.04 v6(95.79,19.08) v6(95.08,19.08) 95.06,19.11 93.58,19.11 92.9,18.42 v6(92.9,16.14) 92.9,15.32 94.39,13.82 99.27,13.82 99.8,13.3 102.73,13.3 v3(102.81,13.21) 113.24,13.21 114.01,12.44 115.23,12.44 115.26,12.47 v3(115.68,12.47) ; 67.87,40.8 67.93,40.86 67.93,41.33 68.44,41.84 v3(68.44,42.14) ; 67.87,40.8 v3(67.85,40.8) ; 67.87,40.8 68.44,40.8 68.92,40.32 v3(69.45,40.32) 69.6,40.16 70.71,40.16 v3(71.16,40.61) ; 94.85,28.61 94.85,29.04 95.11,29.29 95.11,29.39 v3(95.44,29.72) ; 117.1,35.31 v3(116.82,35.31) 116.59,35.08 116.59,34.27 115.71,33.38 114.66,33.38 114.12,32.84 113.28,32.84 112.68,33.44 111.69,33.44 111.44,33.69 111.16,33.69 110.85,33.99 110.85,34.93 110.73,35.06 110.21,35.06 110.09,34.93 110.09,34.35 110.41,34.02 110.41,33.84 111.1,33.15 v2(111.21,33.15) 111.23,33.15 111.37,33.02 112.49,33.02 113.1,32.41 114.41,32.41 114.94,32.95 115.88,32.95 117,34.07 v3(117.43,34.07) 117.61,34.25 117.61,34.8 117.1,35.31 ; 117.1,35.31 117.61,35.82 v2(117.61,36.53) 117.71,36.63 117.71,37.55 v2(117.61,37.65) 117.58,37.67 v2(117.58,38.46) 117.61,38.49 v2(117.61,39.22) v2(117.61,40.27) v2(117.61,41.38) v2(117.61,42.45) 117.61,43 114.69,45.91 114.69,46.97 114.51,47.15 114.51,47.45 114.66,47.61 114.66,47.94 115.15,48.42 115.4,48.42 116.12,47.7 116.12,46.31 119.16,43.26 119.16,35.49 v2(119.44,35.21) ; v6(72.93,9.41) 73.22,9.12 74.41,9.12 75.18,9.89 v3(75.18,10.15) ; v6(72.93,9.41) v6(70.37,9.41) 70.14,9.64 68.01,9.64 v2(67.9,9.53) 67.8,9.43 67.1,9.43 66.89,9.64 61.83,9.64 v3(61.58,9.39) 61.33,9.64 60.85,9.64 60.66,9.82 58.72,9.82 58.26,9.36 55.23,9.36 54.84,8.97 54.16,8.97 v3(54.11,9.02) ; v6(72.93,9.41) 73.15,9.63 73.24,9.63 74.11,10.5 75.05,10.5 75.18,10.38 v3(75.18,10.15) ; v2(111.53,54.32) 111.36,54.14 110.66,54.14 110.58,54.06 v3(109.32,54.06) ; v2(111.53,54.32) 111.53,54.73 110.71,55.56 v3(110.37,55.56) 110.37,55.53 109.75,54.91 109.75,54.49 v3(109.32,54.06) ; v2(111.53,54.32) 111.71,54.14 112.04,54.14 112.33,54.43 112.33,54.92 112.17,55.07 v3(112.17,55.33) ; v3(137.42,61.32) 137.09,61.65 135.11,61.65 133.82,60.36 133.57,60.36 v2(133.28,60.07) 133.13,59.92 v2(133.13,58.76) 133.38,58.5 133.38,57.36 133.88,56.86 133.88,47.26 v3(134.07,47.07) 134.07,46.64 136.19,44.52 137.36,44.52 141.19,40.69 141.19,37.69 141.96,36.92 141.96,35.79 v3(141.73,35.57) 141.96,35.34 141.96,28.57 v2(142.32,28.2) 142.48,28.05 142.48,26.84 141.87,26.23 141.87,23.3 140.42,21.85 137.27,21.85 v3(137.14,21.72) 135.11,21.72 132.34,18.95 v3(131.81,18.95) 131.71,19.06 127.62,19.06 127.07,18.51 123.95,18.51 123.52,18.08 121.79,18.08 v3(121.57,17.87) 120.18,17.87 119.4,17.09 119.4,16.17 118.22,14.99 118.02,14.99 ; v3(137.42,61.32) 137.04,60.94 135.14,60.94 134.52,60.32 v3(134.52,60.02) ; v3(137.42,61.32) 137.78,61.32 138.22,60.89 v3(138.22,60.43) ; v3(105.31,35.57) 105.39,35.49 v2(105.39,34.96) ; v3(18.96,20.87) 20.06,20.87 20.56,21.37 20.56,21.75 v3(20.67,21.86) ; v3(18.96,20.87) 18.96,20.28 18.65,19.97 17.97,19.97 17.31,20.63 17.31,21.67 17.74,22.1 18.12,22.1 v3(18.47,22.46) ; v3(18.96,20.87) 18.96,21.29 18.83,21.5 18.78,21.56 18.7,21.81 18.7,22.23 v3(18.47,22.46) ; 14.15,27.08 14.41,26.82 14.41,24.56 13.33,23.48 v3(12.76,23.48) ; v6(120.71,15.3) 120.53,15.11 119.25,15.11 117.74,13.61 115.65,13.61 114.71,14.54 114.71,16.54 v2(114.87,16.69) 114.94,16.77 114.94,21.29 113.32,22.92 113.32,23.09 v2(113.34,23.12) 113.34,23.12 113.18,23.27 112.99,23.27 111.34,24.92 108.11,24.92 108,24.82 107.02,24.82 v2(105.69,23.49) 105.69,23.39 103.57,21.28 97.57,21.28 95.78,23.06 95.78,24.67 95.59,24.86 95.59,25.18 95.72,25.3 ; v6(120.71,15.3) v6(122.08,15.3) 122.46,15.3 122.97,15.8 v3(122.97,16.49) ; v6(120.71,15.3) v6(120.71,16.72) v6(122.11,16.72) 122.74,16.72 v3(122.97,16.49) ; v3(22.77,38.82) 24.32,38.82 24.6,38.54 v3(24.6,38.21) 24.6,38 24.06,37.47 v6(23.1,37.47) ; v3(22.77,38.82) 21.58,38.82 21.27,38.51 21.27,37.55 21.35,37.47 v3(21.57,37.47) v6(23.1,37.47) ; v3(22.77,38.82) 22.77,37.8 v6(23.1,37.47) ; 116.39,18.65 v2(116.39,18.34) 116.51,18.22 116.51,14.77 v2(116.6,14.69) ; 116.39,18.65 116.7,18.95 116.7,19.38 116.88,19.56 117.2,19.56 v3(117.33,19.69) 117.51,19.51 117.51,19.44 117.91,19.03 117.91,15.1 118.02,14.99 ; 116.39,18.65 116.26,18.78 116.26,21.9 115.35,22.82 v2(115.35,23.12) 115.35,23.45 114.13,24.67 113.52,24.67 112.78,25.41 112.78,25.86 v2(112.96,26.04) 112.96,26.4 112.63,26.73 111.72,26.73 111.31,26.32 v2(111.31,26.17) ; 91.73,13.21 91.54,13.4 87.29,13.4 86.29,14.41 84.4,14.41 v2(84.34,14.47) ; 91.73,13.21 91.73,12.58 92.13,12.17 v3(92.41,12.17) 93.07,11.51 95.82,11.51 95.99,11.69 ; 91.73,13.21 91.94,13.42 92.86,13.42 93.96,12.33 95.74,12.33 95.99,12.07 ; v6(77.25,15.2) v6(76.54,15.2) 76.54,14.21 74.48,12.15 73.43,12.15 72.59,11.31 65.28,11.31 v3(65.13,11.46) 64.96,11.29 62.62,11.29 62.26,11.64 60.41,11.64 60.24,11.47 59.92,11.47 v2(59.8,11.59) 59.68,11.47 58.04,11.47 57.58,11.01 53.7,11.01 52.74,10.04 52.74,8.95 52.05,8.26 51.85,8.26 51.62,8.03 51.62,7.69 51.82,7.49 51.82,7.35 v3(51.93,7.25) 51.74,7.06 51.74,6.32 51.14,5.72 50.4,5.72 49.51,4.83 v3(49.51,4.58) 49.39,4.45 49.13,4.45 48.55,3.87 48.55,3.59 48.67,3.46 50.2,3.46 50.68,3.94 50.68,4.05 51.1,4.47 51.36,4.47 v3(51.47,4.58) 51.57,4.68 51.57,4.94 53.22,6.59 v3(53.22,7.25) 53.22,7.4 54.11,8.29 v3(54.11,9.02) ; v6(77.25,15.2) 77.25,15.63 77.78,16.16 78.14,16.16 78.19,16.21 79.05,16.21 v3(79.4,15.87) ; v6(77.25,15.2) 77.28,15.17 77.94,15.17 v6(77.96,15.2) v6(78.67,15.2) 78.72,15.2 v3(79.4,15.87) ; v3(20.99,24.87) 20.94,24.82 19.34,24.82 19.03,24.52 v3(19.03,23.6) ; v3(20.99,24.87) 21.04,24.82 21.04,22.92 20.84,22.71 20.84,22.03 v3(20.67,21.86) ; v3(20.99,24.87) 21.37,24.87 21.9,24.34 v3(21.9,24.06) 21.9,23.96 22.18,23.68 22.18,21.62 v3(21.9,21.34) 21.55,21.7 20.84,21.7 v3(20.67,21.86) ; v3(20.99,24.87) 20.99,25.2 21.75,25.96 21.75,26.3 v3(21.9,26.45) ; v3(15.87,36.16) 15.7,36.16 14.39,34.85 14.39,34.34 13.51,33.47 13.51,31.55 13.06,31.1 13.06,30.21 14.3,28.97 14.3,28.81 14.85,28.26 14.85,27.38 15.15,27.08 15.15,25.03 v3(15.25,24.92) 15.07,24.75 15.07,24.38 13.47,22.78 13.47,21.49 v2(13.17,21.19) v2(12.66,21.19) 12.15,21.19 11.95,21.39 v2(11.95,21.9) 12.05,21.9 12.25,22.1 12.25,22.97 v2(12.3,23.02) ; v3(21.9,26.45) 21.42,26.45 21.27,26.3 v2(20.43,26.3) ; v3(21.9,26.45) 22.31,26.04 22.97,26.04 23.35,26.42 23.35,27.18 22.97,27.57 22.46,27.57 22.31,27.41 v3(22.03,27.41) ; v3(21.9,26.45) 22.03,26.57 v3(22.03,27.41) ; v3(10.93,50.32) 9.84,50.32 9.41,50.76 8.42,50.76 8.24,50.93 ; v3(10.93,50.32) 11.08,50.17 11.77,50.17 11.97,50.38 11.97,51.39 v3(12.15,51.57) ; v3(10.93,50.32) 10.98,50.37 10.98,51.44 10.7,51.72 v3(10.47,51.72) 10.24,51.95 10.24,52.91 v2(10.63,53.3) ; v3(19.03,23.6) 19.03,23.04 ; v3(19.03,23.6) 18.6,23.6 v3(17.48,24.72) 17.28,24.93 17.28,26.12 v3(17.68,26.53) ; v2(86.65,15.8) 86.6,15.75 86.6,15.08 87.6,14.08 88.83,14.08 89.26,14.51 89.26,14.97 v3(89.39,15.09) 90.23,14.26 v3(90.79,14.26) v3(91.6,15.07) ; v2(86.65,15.8) 87.1,16.26 88.53,16.26 88.96,16.69 v6(89.04,16.69) ; v2(86.65,15.8) 86.65,15.86 86.52,15.98 85.26,15.98 84.58,15.3 84.58,15 84.34,14.76 v2(84.34,14.47) ; v2(97.6,23.38) 97.01,23.38 v3(96.76,23.63) 96.76,24.17 96.72,24.21 96.72,25.24 96.23,25.73 96.23,26.15 95.54,26.84 95.54,27.72 95.39,27.87 v2(95.33,27.87) ; v2(97.6,23.38) 97.6,24.97 96.72,25.85 96.72,26.84 v2(96.5,27.06) 95.96,27.6 95.96,28.98 95.54,29.41 95.54,29.63 v3(95.44,29.72) ; v2(97.6,23.38) 99,21.98 100.01,21.98 v3(100.19,22.15) 100.31,22.15 100.54,21.93 102.9,21.93 v3(103.31,22.33) ; v2(20.43,26.3) v2(19.29,26.3) 19.13,26.14 v2(18.65,26.14) 18.07,26.14 v3(17.68,26.53) ; v2(20.43,26.3) 20.4,26.32 20.4,27.13 19.97,27.57 19.97,28.96 ; v3(46.39,23.68) 46.41,23.65 46.41,22.15 47.22,21.35 47.22,19.2 v6(46.49,18.47) 46.49,17.58 v6(46.16,17.25) 46.31,17.1 46.31,16.74 43.92,14.36 43.92,12.2 44.41,11.71 44.41,8.15 45.96,6.61 v3(45.96,6.1) 46.1,5.96 46.1,5.71 46.42,5.39 46.88,5.39 47.42,5.92 v3(47.49,5.92) 47.49,6.4 47.15,6.74 46.8,6.74 45.89,7.64 v3(45.89,7.89) 46.16,8.16 46.16,8.72 46.5,9.06 v3(46.5,9.44) 46.5,11.53 45.68,12.35 v3(45.68,12.45) 46.16,12.45 v3(46.74,13.04) 46.83,13.12 46.83,13.84 47.12,14.14 47.12,15.4 48.75,17.03 48.75,20.99 v3(48.94,21.18) 48.94,21.23 49.08,21.37 49.94,21.37 50.1,21.22 v3(50.15,21.22) ; v3(46.39,23.68) 46.57,23.86 50.4,23.86 v3(50.63,23.63) ; v3(46.39,23.68) 46.21,23.86 44.89,23.86 43.9,22.87 43.9,19.95 v3(44.1,19.74) 43.9,19.54 43.9,19.41 40.65,16.16 39.2,16.16 v3(39.12,16.24) ; 81.68,41.45 81.18,41.45 80.59,42.05 80.59,42.16 78.09,44.66 v2(78.09,44.76) 78.09,44.89 77.07,45.91 77.07,51.84 77.65,52.42 ; v3(80.31,25.42) 80.67,25.06 v2(82.22,25.06) ; v2(105.95,27.13) 106.28,26.81 107.2,26.81 107.28,26.89 108.15,26.89 109.65,28.38 114.48,28.38 115.4,29.3 115.4,29.86 116.14,30.61 116.14,31.34 117.07,32.26 117.69,32.26 119.54,34.12 v3(119.54,34.7) ; 113.69,53.03 114.36,52.37 v3(115.02,52.37) 117.78,52.37 v2(117.79,52.38) 117.81,52.36 v3(118.27,52.36) 118.5,52.36 118.8,52.05 118.8,50.64 118.75,50.58 v2(118.32,50.58) v2(117.86,50.58) 117.61,50.58 117,51.19 114.96,51.19 114.53,51.62 114.17,51.62 113.43,52.36 111.59,52.36 111.43,52.52 v3(111.23,52.52) 111.06,52.35 104.23,52.35 103.1,51.22 103.1,50.49 v2(102.89,50.27) 102.89,50.68 102.6,50.97 99.94,50.97 99.39,50.41 99.39,48.46 98.23,47.3 98.23,46.36 97.85,45.98 97.85,45.07 97.2,44.41 96.96,44.41 95.46,42.91 95.46,42.73 v2(95.26,42.53) ; 113.69,53.03 113.88,53.22 114.03,53.22 v3(114.23,53.42) 114.23,53.81 113.84,54.2 113.84,54.5 113.41,54.93 112.78,54.93 112.38,55.33 v3(112.17,55.33) ; 113.69,53.03 111.98,53.03 111.66,53.36 110.83,53.36 110.48,53.01 103.95,53.01 ; 70.63,40.89 70.63,40.9 ; 70.63,40.9 70.1,41.42 70.1,42.08 v2(69.78,42.4) ; 70.63,40.9 70.92,40.61 v3(71.16,40.61) ; v2(94.09,30.75) 94.01,30.67 94.01,29.27 93.79,29.04 93.79,28.56 v3(93.81,28.53) 93.81,28.12 v3(93.91,28.02) 93.62,27.73 93.62,26.85 92.97,26.2 92.97,24.67 93.02,24.62 ; 78.78,59.65 80.42,61.3 v2(80.78,61.3) v2(82.05,61.3) v2(83.32,61.3) v2(84.59,61.3) v2(85.86,61.3) 86.38,61.3 v3(86.62,61.54) v2(88.2,61.54) v2(89.95,61.54) v3(91.67,61.54) 94.85,61.54 v3(94.88,61.57) 95.43,62.12 v2(103.28,62.12) 111.41,62.12 114.75,58.78 115.58,58.78 115.93,58.42 115.93,57.36 117.45,55.85 117.67,55.85 v2(117.94,55.58) 118.27,55.58 118.73,55.12 118.73,54.57 119.62,53.68 122.35,53.68 122.41,53.73 v2(122.41,53.78) ; v3(17.13,37.47) 16.31,38.29 16.31,41.93 16.06,42.18 16.06,45.24 16.74,45.92 16.83,45.92 16.85,45.9 16.9,45.9 v3(16.92,45.88) 16.92,45.9 16.98,45.95 17.17,45.95 17.24,46.02 18.41,46.02 18.45,45.98 v3(18.47,45.98) 18.9,45.98 19.53,45.35 21.72,45.35 v3(21.89,45.52) 22.02,45.52 22.41,45.9 22.41,46.28 v3(21.65,47.05) ; v2(84.06,25.43) 83.31,25.43 v3(83.17,25.3) ; 16.49,52.81 v2(16.49,52.78) ; v2(16.49,52.78) 16.3,52.78 15.93,53.14 v3(15.32,53.14) ; v2(16.49,52.78) 16.69,52.78 16.92,53.02 v3(16.92,54.36) 16.16,54.36 15.32,53.52 v3(15.32,53.14) ; v2(16.49,52.78) 16.49,52.13 v3(15.82,51.45) 15.57,51.45 15.12,51.9 15.12,52.94 v3(15.32,53.14) ; v3(12.15,51.57) 12.22,51.5 12.22,50.93 12.6,50.55 13.47,50.55 13.57,50.65 13.65,50.65 v3(13.67,50.68) 13.72,50.73 13.72,51.14 11.34,53.52 11.34,54.49 11.18,54.64 v3(11.01,54.64) 10.5,54.64 10.32,54.46 10.32,53.6 v2(10.63,53.3) ; v3(12.15,51.57) 12.1,51.62 12.1,51.92 10.73,53.3 v2(10.63,53.3) ; v3(86.62,34.37) 86.84,34.14 87.13,34.14 87.28,33.99 87.28,33.58 87.21,33.51 87.21,33.03 ; v2(9.88,27.18) v3(10.01,27.49) ; v3(138.22,60.43) 138.22,60.31 137.9,60 137.9,59.26 137.22,58.58 136.51,58.58 136.3,58.78 ; v3(138.22,60.43) 138.24,60.41 139.86,60.41 140.06,60.2 140.06,59.7 139.45,59.09 v2(139.13,59.09) 138.59,59.09 135.97,56.47 135.97,48.48 137.7,46.75 138.33,46.75 141.13,43.95 v3(141.46,43.95) 141.46,43.62 144.05,41.03 144.05,33.74 144.23,33.56 v3(144.23,33.46) 144.23,33.41 144.05,33.23 144.05,31.29 v3(144.26,31.08) 144.29,31.05 v3(144.29,30.45) 145.52,29.21 145.52,26.73 143.92,25.13 143.92,22.31 143.67,22.05 143.67,20.83 143.01,20.17 143.01,18.09 v6(142.48,17.56) v6(140.7,17.56) v6(138.92,17.56) 137.45,19.03 v3(136.25,19.03) ; v3(138.22,60.43) 138.14,60.51 137.22,60.51 v2(136.89,60.18) ; 16.22,29.87 16.07,29.71 16.07,29.31 16.22,29.16 16.48,29.16 17,28.64 ; v3(122.97,16.49) 124.35,17.87 128.75,17.87 v6(128.79,17.91) v6(129.65,17.91) v6(130.56,17.91) 130.69,18.04 132.65,18.04 135.26,20.66 138.59,20.66 v3(139.57,19.68) ; v3(108.44,37.66) 108.45,37.66 108.82,37.66 v8(108.82,37.65) ; v3(21.65,47.05) 22.49,47.89 v3(22.49,48.38) 22.89,48.38 23.36,48.84 35.28,48.84 35.74,48.38 35.74,48.08 36.56,47.27 38.46,47.27 40.03,48.84 57.35,48.84 57.46,48.95 58.48,48.95 59.82,50.29 62.03,50.29 62.77,51.03 63.58,51.03 67.04,54.49 67.04,58.93 71.23,63.13 71.62,63.13 73.26,64.77 73.26,65.28 75.37,67.39 124.49,67.39 v3(124.7,67.19) 124.9,67.39 126.4,67.39 v3(126.6,67.19) 126.6,66.84 v2(126.47,66.71) 125.84,66.08 124.52,66.08 123.81,66.79 75.65,66.79 73.86,65 73.86,64.53 71.8,62.46 71.53,62.46 67.93,58.86 67.93,54.51 63.85,50.44 63.01,50.44 62.27,49.69 60.17,49.69 58.84,48.36 57.71,48.36 57.6,48.25 41.44,48.25 v6(41.21,48.01) v6(40.5,48.01) 40.06,48.01 38.7,46.65 38.04,46.65 37.6,46.21 36.66,46.21 v6(34.86,48.01) v6(34.15,48.01) v6(33.43,48.01) 33.21,48.24 23.74,48.24 23.02,47.52 23.02,45.52 22.25,44.75 18.54,44.75 18.43,44.86 17.15,44.86 v3(17,44.71) 17,44.66 16.72,44.38 16.72,42.63 v3(16.83,42.53) 17.05,42.3 v2(17.05,42.2) 16.9,42.05 16.9,38.79 17.9,37.79 17.9,37.1 16.18,35.39 15.91,35.39 15.13,34.61 15.13,34.05 14.77,33.69 v3(14.77,33.32) ; v3(21.65,47.05) 21.32,46.72 20,46.72 19.87,46.84 18.55,46.84 v3(18.22,47.17) 18.17,47.17 17.84,46.84 16.54,46.84 v2(16.52,46.87) ; v3(17.28,28.3) 17.6,28.62 17.6,28.8 17.97,29.17 v3(17.97,30) ; 78.11,45.48 77.5,46.09 77.5,51.48 77.93,51.91 78.03,51.91 78.11,51.99 ; v2(10.63,53.3) 9.94,53.3 9.16,54.07 9.16,55.54 9.76,56.14 9.76,56.72 9.33,57.16 7.68,57.16 7.63,57.21 v2(7.63,57.74) 8.39,57.74 8.76,58.11 v2(9.38,58.11) 9.78,58.11 10.18,57.71 10.18,57.37 10.63,56.93 10.63,56.65 12.48,54.79 12.48,53.52 13.19,52.81 v2(13.57,52.81) 13.57,53.09 13.47,53.19 13.47,54.62 11.18,56.9 11.18,57.05 10.73,57.51 10.73,57.92 9.86,58.78 8.1,58.78 v2(7.93,58.95) ; v2(94.06,33.13) 94.06,33.94 93.68,34.32 93.3,34.32 92.74,34.88 92.17,34.88 91.91,35.14 91.26,35.14 89.9,36.51 89.57,36.51 89.47,36.61 89.21,36.61 88.99,36.39 v8(88.64,36.39) ; v2(94.06,33.13) 94.31,33.13 95.23,32.21 95.23,30.13 95.44,29.92 v3(95.44,29.72) ; v2(94.06,33.13) 93.89,33.13 93.37,32.61 93.37,31.65 93.56,31.46 v2(93.58,31.46) ; v2(8.11,54.18) 9.41,52.88 9.41,52.11 v3(9.06,51.76) 8.42,51.76 v3(8.24,51.95) 8.24,50.93 ; v2(8.11,54.18) 7.6,54.68 7.6,56.06 v2(7.77,56.23) 8.37,56.23 8.44,56.16 8.44,54.51 v2(8.11,54.18) ; v3(64.42,24.8) 64.19,25.03 62.32,25.03 61.88,24.59 61.88,23.7 v3(62.06,23.53) ; v3(64.42,24.8) 64.42,23.15 v3(64.47,23.09) 64.5,23.07 64.5,22.96 64.19,22.66 62.77,22.66 62.06,23.37 v3(62.06,23.53) ; v3(64.42,24.8) 64.8,24.8 65.24,24.36 v3(67.78,24.36) 68.41,24.36 68.56,24.52 71.66,24.52 72.04,24.14 ; 136.3,58.78 136.3,59.06 136.53,59.29 136.53,59.62 136.74,59.82 136.74,60.03 v2(136.89,60.18) ; 136.3,58.78 136.1,58.58 136.1,57.87 135.43,57.2 135.43,48.19 137.44,46.19 138.09,46.19 143.26,41.02 v3(143.26,40.75) 143.26,39.57 143.49,39.34 143.49,30.21 143.96,29.74 143.96,29.48 v3(144.14,29.3) 144.53,28.91 144.53,27.64 v3(144.76,27.41) 144.76,26.75 143.37,25.36 143.37,22.54 143.11,22.28 143.11,21.6 v3(142.93,21.42) 143.11,21.24 143.11,21.06 142.41,20.36 142.41,19.17 141.59,18.34 139.23,18.34 137.8,19.77 135.59,19.77 133.47,17.65 133.47,17.27 133.31,17.1 v3(133.26,17.1) 133.21,17.1 132.85,16.74 125.47,16.74 125.41,16.69 v3(125.41,16.67) 125.27,16.53 124.96,16.53 122.54,14.1 119.43,14.1 118.09,12.76 115.97,12.76 v3(115.68,12.47) ; v3(112.17,55.33) 112.17,55.76 110.73,57.21 108.69,57.21 108.34,56.86 v2(107.39,56.86) ; 79.43,59.65 80.36,60.59 v2(85.02,60.59) 95.39,60.59 v2(95.55,60.75) 96.4,61.6 106.71,61.6 v2(106.82,61.5) 111.43,61.5 114.86,58.07 115.2,58.07 v2(115.39,57.88) 115.3,57.78 v3(115.3,57.38) 115.58,57.11 115.58,56.75 v2(115.68,56.65) ; 19.97,28.96 20.56,28.96 v6(20.81,28.71) 21.17,28.71 21.57,28.3 v3(21.78,28.3) 22.08,28 22.08,27.82 v2(22.11,27.79) 22.03,27.72 v3(22.03,27.41) ; 19.97,28.96 19.41,28.96 v6(19.24,28.78) 18.91,28.78 18.14,28.02 18.14,27.74 v2(18.09,27.69) 18.09,27.39 17.79,27.08 17.79,26.64 v3(17.68,26.53) ; v3(114.71,54.13) 114.84,54.01 115.77,54.01 115.93,53.85 115.93,53.52 116.24,53.22 117.74,53.22 v2(117.84,53.12) 118.37,53.12 119.72,51.76 122.46,51.76 122.66,51.56 123.11,51.56 123.25,51.69 123.25,52.32 122.99,52.58 120.38,52.58 v3(120.12,52.33) 119.61,52.33 118.01,53.93 v2(117.84,53.93) 117.46,54.31 114.89,54.31 v3(114.71,54.13) ; v3(114.71,54.13) 114.61,54.13 114.16,54.59 114.16,54.94 112.84,56.26 112.84,56.36 ; v3(109.32,54.06) 108.95,53.68 103.67,53.68 ; v2(105.97,59.86) 105.88,59.86 105.63,59.6 105.31,59.6 104.75,60.16 v3(104.75,60.49) ; v2(111.31,26.17) 110.98,25.84 v3(110.7,25.84) 110.53,26.02 109.51,26.02 109.06,25.56 107.84,25.56 107.74,25.46 106.28,25.46 104.44,23.62 v2(104.44,23.36) 104.44,23.23 103.54,22.33 v3(103.31,22.33) ; v2(111.31,26.17) 111.9,25.58 111.9,25.33 113.24,23.98 113.8,23.98 114.38,23.4 114.38,23.15 v3(114.41,23.12) 114.38,23.09 114.38,22.84 115.6,21.63 115.6,18.02 115.83,17.79 115.83,15.87 v2(115.63,15.67) 115.46,15.51 115.46,14.7 115.68,14.48 116.39,14.48 v2(116.6,14.69) ; v3(139.57,19.68) 139.89,19.36 141.08,19.36 141.38,19.67 v3(141.38,21.19) 140.88,21.19 140.06,20.38 140.06,20.17 v3(139.57,19.68) ; v6(90.1,17.18) 90.1,17.38 93.79,21.06 93.96,21.06 95.07,22.18 v2(95.44,22.18) ; v6(90.1,17.18) 89.52,17.18 v6(89.04,16.69) ; v6(90.1,17.18) 90.23,17.05 90.23,16.67 v6(90.43,16.47) v6(89.72,16.47) 89.26,16.47 v6(89.04,16.69) ; v6(90.1,17.18) 90.91,17.18 91.12,17.38 91.37,17.38 91.7,17.05 91.7,15.17 v3(91.6,15.07) ; 112.84,56.36 113.39,56.36 113.55,56.52 114.66,56.52 ; 112.84,56.36 110.74,58.47 109.31,58.47 108.58,59.2 v3(107.89,59.2) 105.91,59.2 105.74,59.03 v2(105.74,58.89) ; v3(68.49,45.17) 68.41,45.24 68.41,46.62 68.69,46.89 68.82,46.89 69.02,47.1 v3(69.1,47.1) 69.3,47.1 70.39,46.01 v3(70.39,45.57) ; v3(68.49,45.17) 68.82,44.84 68.82,43.95 68.97,43.8 v2(69.76,43.8) 69.76,43.79 70.84,43.79 v3(71,43.94) 71,44.03 71.65,44.68 72.29,44.68 v3(72.55,44.94) ; v3(68.49,45.17) 68.46,45.14 68.46,42.17 v3(68.44,42.14) ; v3(68.49,45.17) 69.2,45.17 69.35,45.32 v2(69.73,45.32) 70.14,45.32 v3(70.39,45.57) ; v6(63.44,28.21) 63.02,27.8 61.87,27.8 61.71,27.63 61.71,27.31 61.86,27.16 64.32,27.16 ; v2(116.6,14.69) 116.8,14.48 117,14.48 117.2,14.28 117.51,14.28 117.89,14.67 117.89,14.87 118.02,14.99 ; v3(134.52,60.02) 134.32,60.02 133.74,59.44 133.74,58.83 v2(133.88,58.69) ; v3(134.52,60.02) 134.68,59.87 134.68,59.19 134.18,58.69 v2(133.88,58.69) ; v3(103.31,22.33) 102.37,23.27 102.37,23.39 v2(102.19,23.57) v2(100.69,23.57) v2(99.65,23.57) 99.35,23.57 98.65,24.27 98.65,25.45 97.77,26.33 97.77,27.41 97.25,27.94 97.25,28.95 96.5,29.7 96.5,30.93 v2(96.41,31.02) 96.4,31.03 96.4,34.52 96.09,34.84 94.49,34.84 93.95,35.38 v3(93.72,35.38) ; 96.9,45.15 96.61,45.15 95.54,44.08 ; 19.03,23.04 19.36,22.71 20.38,22.71 20.58,22.51 20.58,21.95 v3(20.67,21.86) ; 19.03,23.04 19.03,23.02 v3(18.47,22.46) ; v2(105.74,58.89) 105.05,58.89 104.51,58.36 v2(104.39,58.36) 104.27,58.48 102.75,58.48 102.52,58.71 102.52,59.29 102.24,59.57 v2(100.74,59.57) 100.74,59.91 v3(101.02,60.19) 97.13,60.19 v3(96.88,60.43) ; v2(105.74,58.89) 105.94,58.89 106.28,58.56 106.28,57.94 106.1,57.76 106.1,57.65 ; 95.72,25.3 95.72,26.02 94.78,26.96 94.78,27.82 v2(94.83,27.87) ; 95.72,25.3 96.05,25.3 96.25,25.1 v2(96.25,24.67) 96.12,24.54 96.12,23.17 97.7,21.6 103.36,21.6 105.09,23.32 105.09,23.63 106.6,25.14 107.87,25.14 107.97,25.24 109.51,25.24 v3(109.74,25.47) 109.96,25.24 111.5,25.24 113.11,23.63 113.55,23.63 113.85,23.32 113.85,22.84 115.28,21.41 115.28,17.79 115.41,17.66 115.41,16.33 v2(115.2,16.13) 115.12,16.05 115.12,14.59 115.78,13.93 117.61,13.93 119.72,16.04 119.72,16.95 120.08,17.31 122.07,17.31 122.29,17.54 v3(122.49,17.54) 123.43,17.54 124.08,18.19 127.68,18.19 127.97,18.48 v3(128,18.48) 128.02,18.51 131.11,18.51 131.26,18.36 132.51,18.36 135.14,20.99 137.55,20.99 137.78,21.22 v3(138.41,21.22) 140.29,21.22 142.19,23.11 142.19,26.09 143.11,27.02 v3(143.11,27.95) 143.11,28.2 142.28,29.04 142.28,37.65 v3(141.97,37.95) 141.51,38.41 141.51,41.01 137.68,44.84 136.73,44.84 136.5,45.08 v3(136.5,45.14) 136.5,45.18 134.86,46.82 134.86,47.07 134.22,47.7 134.22,57 133.79,57.44 133.79,58.6 v2(133.88,58.69) ; v3(75.18,10.15) 78.33,13.3 79.5,13.3 79.84,13.64 v2(80.28,13.64) 80.37,13.73 86.12,13.73 87.06,12.79 89.86,12.79 v3(90.78,11.88) 91.74,10.91 98.65,10.91 99.18,11.45 101.45,11.45 101.77,11.13 112.63,11.13 v3(112.93,10.83) 113.04,10.72 114.6,10.72 115.16,10.16 117.16,10.16 117.53,10.53 v3(117.53,10.82) ; v3(126.6,16.01) 126.6,15.22 126.04,14.66 125,14.66 123.3,12.96 120,12.96 117.86,10.82 v3(117.53,10.82) ; v3(126.6,16.01) 126.42,16.19 125.94,16.19 125.42,15.67 124.99,15.67 122.88,13.56 119.65,13.56 118.13,12.04 v3(117.66,12.04) 117.27,11.65 115.36,11.65 115.1,11.9 113.78,11.9 113.18,12.5 104.28,12.5 v3(104.28,12.5) ; v3(126.6,16.01) 126.78,16.19 133.46,16.19 134.22,16.95 v2(134.22,17.41) 134.6,17.79 134.6,17.99 135.64,19.03 v2(135.82,19.03) ; v2(21.78,40.87) 21.8,40.85 22.82,40.85 23.78,39.88 v3(24.62,39.88) ; v2(38.89,22.66) 38.89,22.67 38.92,22.7 39.27,22.7 39.46,22.5 40.02,22.5 40.43,22.91 40.43,24.53 42.73,26.82 42.73,27.23 44.9,29.41 47.52,29.41 49.67,27.26 59.78,27.26 60.23,27.71 60.23,28.49 61.04,29.31 v3(61.04,29.32) 61.07,29.34 61.08,29.34 61.72,29.98 62.93,29.98 v6(63.15,30.2) ; 8.24,50.93 v6(8.11,51.06) ; 44.59,26.99 v6(45.31,26.99) 46.24,27.92 v6(46.78,27.92) 46.79,27.92 v6(47.5,27.21) 47.52,27.18 47.53,27.18 47.68,27.03 48.1,27.03 48.4,26.74 48.4,26.4 48.19,26.19 45.86,26.19 45.74,26.31 v3(45.74,26.36) 44.84,26.36 44.59,26.61 44.59,26.99 ; 44.59,26.99 v6(44.59,26.99) ; v3(92.01,40.04) 92.19,39.86 94.29,39.86 94.7,40.27 95.13,40.27 95.95,41.08 96.55,41.08 96.89,41.42 96.89,43.07 v3(97.09,43.27) 97.67,43.85 97.67,44.27 98.28,44.89 98.28,45.65 98.8,46.17 98.8,46.49 100.96,48.65 v3(103.64,48.65) 103.64,48.2 104.62,47.21 105.7,47.21 105.8,47.12 105.8,45.72 ; 108.87,31.45 108.57,31.45 108.39,31.27 108.39,30.59 107.78,29.98 107.78,29.7 108.06,29.42 ; v2(115.68,56.65) 115.3,56.27 114.92,56.27 114.66,56.52 ; v2(115.68,56.65) 116.04,56.65 117.69,55 117.92,55 v2(117.99,54.92) 118.2,54.71 118.2,54.49 119.52,53.17 127.92,53.17 128.35,52.74 v3(128.35,52.41) 129.27,51.49 129.27,49.16 129.47,48.95 129.9,48.95 129.95,49.01 129.95,51.77 128.41,53.31 v3(128.41,53.55) 128.34,53.63 123.3,53.63 v3(123.07,53.85) ; v3(117.53,10.82) 117.29,11.06 115.11,11.06 114.86,11.31 113.54,11.31 113.12,11.73 102.01,11.73 101.66,12.08 98.22,12.08 v6(98.2,12.1) ; v6(98.2,12.1) 97.65,12.66 96.58,12.66 95.99,12.07 ; v6(98.2,12.1) 97.93,12.1 97.34,11.51 96.17,11.51 95.99,11.69 ; v2(95.44,22.18) 95.11,22.5 95.11,24.39 94.92,24.59 94.92,24.86 94.6,25.18 94.6,25.46 94.83,25.69 94.88,25.69 v2(94.9,25.71) 94.8,25.71 94.57,25.94 94.57,26.24 94.42,26.4 94.42,27.82 v3(94.37,27.87) ; v2(136.89,60.18) 136.51,60.56 135.36,60.56 135.11,60.31 135.11,59.16 134.15,58.2 134.15,57.54 134.54,57.14 134.54,47.89 137.09,45.34 137.7,45.34 142.05,40.99 142.05,39.2 v3(142.07,39.17) 142.07,38.69 142.6,38.15 142.6,29.47 v2(142.86,29.22) 142.86,29.01 143.67,28.21 143.67,26.98 142.51,25.82 142.51,22.92 141.59,22 141.59,21.73 v2(141.46,21.6) ; 106.1,57.65 106.05,57.6 v3(105.36,57.6) 105.35,57.61 104.07,57.61 ; 106.1,57.65 106.1,57.59 106.56,57.13 106.89,57.13 v3(106.92,57.11) ; 95.99,11.69 95.99,12.07 ; 72.04,24.14 71.92,24.01 70.57,24.01 69.81,23.25 v3(69.55,23.25) 69.53,23.22 v3(69.53,21.6) 69.53,21.42 69.88,21.06 70.8,21.06 v3(71.38,21.65) 71.38,22.13 72.72,23.46 ; 72.04,24.14 72.72,23.46 ; v3(106.13,35.52) 106.13,33.95 106.42,33.66 106.42,32.43 105.77,31.78 105.77,31.6 ; v3(79.4,15.87) 79.55,15.87 79.92,15.5 82.38,15.5 83.24,16.36 84.08,16.36 84.51,16.8 v3(84.51,16.97) 84.69,16.97 85.05,17.33 87.54,17.33 v2(87.69,17.48) 88.45,18.24 89.34,18.24 93.36,22.26 93.66,22.26 94.04,22.64 94.04,23.63 93.73,23.93 93.73,24.44 93.56,24.62 93.02,24.62 ; v3(68.44,42.14) 69.53,42.14 v2(69.78,42.4) ; 114.66,56.52 114.66,57.56 111.29,60.94 106.23,60.94 106.01,61.16 97.61,61.16 v3(96.88,60.43) ; v3(91.6,15.07) 91.88,14.79 92.5,14.79 94.02,13.26 98.99,13.26 99.59,12.67 101.92,12.67 102.27,12.32 103.36,12.32 v2(103.61,12.57) ; v3(84.33,25.72) 84.7,25.36 v2(85.1,25.36) 85.33,25.36 85.79,25.82 85.79,27.34 85.76,27.36 85.76,28.5 87.05,29.79 87.05,30.1 88.09,31.13 88.09,32.77 87.56,33.3 87.56,34.09 87.26,34.38 87.26,34.66 v3(87.23,34.69) ; v2(80.17,25.05) 80.09,25.05 77.71,27.43 v3(77.71,27.97) ; 88.88,40.98 88.9,40.96 89.2,40.96 89.4,40.76 v8(89.43,40.76) 89.51,40.69 91.01,40.69 91.62,41.3 92.92,41.3 93.58,41.97 v3(93.58,42.02) ; 76.61,57.61 76.61,57.79 76.61,57.79 76.61,59.15 79.85,62.39 v2(80.53,62.39) v2(81.8,62.39) v2(83.07,62.39) v2(84.34,62.39) v2(85.61,62.39) 85.66,62.44 94.45,62.44 94.86,62.85 115.88,62.85 v1(117.84,60.89) v6(121.14,60.89) 121.34,60.89 121.9,60.33 v3(123.35,60.33) 123.55,60.33 124.19,60.97 124.65,60.97 125.72,62.04 127.85,62.04 128.61,61.29 128.61,60.51 v3(128.91,60.2) 129.78,60.2 130.16,60.59 v3(130.28,60.59) 130.28,60.97 129.28,61.97 128.69,61.97 128.08,62.58 125.48,62.58 124.49,61.6 123.07,61.6 v3(122.89,61.42) 122.31,61.42 v2(121.95,61.78) v2(121.47,61.78) v2(120.96,61.78) v2(120.46,61.78) 120.05,61.78 119.9,61.63 117.95,61.63 116.19,63.39 93.94,63.39 v3(93.76,63.2) v3(88.68,63.2) 78.65,63.2 v3(78.46,63.01) 78.32,62.87 78.32,61.78 76.06,59.52 76.06,56.2 v2(75.92,56.06) ; 76.61,57.61 76.61,45.77 77.57,44.82 77.57,44.54 78.21,43.9 78.25,43.9 78.65,43.5 ; 76.61,57.61 76.74,57.61 77.73,58.6 ; v2(84.34,14.47) 84.31,14.45 79.75,14.45 79.2,13.9 77.86,13.9 v2(77.76,13.8) v8(75.14,11.18) 75.05,11.09 73.86,11.09 73,10.23 67.48,10.23 v2(67.38,10.13) 67.27,10.23 61.35,10.23 v3(61.17,10.4) 61.16,10.42 58.47,10.42 58.01,9.96 54.15,9.96 53.88,9.68 53.88,9.25 v3(54.11,9.02) ; v3(62.06,23.53) 61.73,23.53 60.77,22.56 58,22.56 57.88,22.67 55.59,22.67 55.11,23.15 55.11,23.69 54.94,23.86 51.06,23.86 50.83,23.63 v3(50.63,23.63) ; v2(50.45,21.47) 51.77,20.15 54.29,20.15 54.52,20.38 v2(54.8,20.38) ; v2(69.78,42.4) v3(70.75,42.4) 70.95,42.4 71.36,41.99 71.36,41.7 71.48,41.58 v2(71.48,41.04) ; 105.68,33.45 v2(105.65,33.48) 105.32,33.81 105.32,34.53 v3(105.34,34.56) ; 106.13,29.01 105.52,29.01 v2(105.49,29.04) 105.01,29.52 v2(105.01,29.71) 105.01,30.96 105.16,31.11 105.16,31.97 105.73,32.54 ; 95.49,37.27 95.49,36.86 95.33,36.71 95.08,36.71 94.81,36.98 94.81,38.38 94.65,38.54 94.65,38.66 94.8,38.82 95.06,38.82 v2(95.31,38.56) 95.31,38.26 95.06,38 95.06,37.45 95.23,37.27 95.49,37.27 ; 95.49,37.27 95.64,37.42 95.89,37.42 v2(95.92,37.45) 98.03,39.55 98.03,40.47 97.75,40.75 97.75,41.54 98.03,41.81 v3(98.03,42.25) 98.03,42.42 98.18,42.58 98.18,43.11 98.51,43.44 98.51,43.92 99.12,44.54 99.12,45.3 99.64,45.81 99.64,46.14 101.2,47.71 102.87,47.71 104.17,46.41 v2(104.17,46.31) ; 95.07,42.53 v2(95.26,42.53) ; v2(95.26,42.53) 95.36,42.42 95.46,42.42 95.72,42.17 95.72,41.84 95.49,41.61 95.23,41.61 95.06,41.79 94.65,41.79 v2(94.53,41.92) 94.14,41.92 93.79,41.56 93.58,41.56 93.02,41 91.68,41 91.07,40.39 89.29,40.39 89.12,40.56 88.94,40.56 88.83,40.67 88.83,40.98 88.84,40.98 ; 72.72,23.46 75.31,20.87 75.31,20.85 v2(75.88,20.28) 76.13,20.28 77.27,19.13 v2(80.2,19.13) 84,19.13 84.07,19.06 87.23,19.06 87.58,19.42 88.79,19.42 92.73,23.36 92.73,24.06 92.96,24.29 92.96,24.55 93.02,24.62 ; v3(96.88,60.43) 96.86,60.45 96.15,60.45 95.76,60.06 85.21,60.06 v2(85.1,59.95) 84.99,60.06 80.43,60.06 80.03,59.65 ; v3(96.88,60.43) 96.5,60.05 v2(96.5,57.05) 96.48,57.03 v2(96.48,53.09) 96.48,53.02 95.88,52.42 95.88,49.47 94.73,48.32 94.62,48.32 ; 78.65,43.5 80.16,41.99 80.16,41.87 81.05,40.99 82.1,40.99 82.17,40.91 82.17,40.6 ; 78.65,43.5 78.39,43.24 77.55,43.24 77.25,43.54 77.25,44.09 76.95,44.4 76.95,44.65 76.07,45.52 76.07,46.69 75.9,46.86 v2(75.9,47.02) ; 17.34,26.58 17.13,26.78 17.13,27.66 17.29,27.82 ; v2(85.07,26.37) 85.28,26.57 85.28,27.69 85.12,27.84 v3(85.12,28.07) 85.12,28.46 86.62,29.96 86.62,30.28 87.66,31.32 87.66,31.91 ; v3(72.55,44.94) 73.06,44.43 v3(73.06,44.13) 73.32,43.87 73.32,42.48 72.89,42.05 72.89,40.38 72.7,40.19 71.57,40.19 v3(71.16,40.61) ; v3(72.55,44.94) 72.27,45.22 71.96,45.22 71.6,45.57 v3(70.39,45.57) ; v2(21.45,42.17) 23,42.17 v3(23.27,42.45) ; v2(8.24,52.36) 8.24,52.97 7.7,53.5 6.82,53.5 CON7101.B1 ; v3(107.88,32.49) 107.76,32.62 107.76,33.48 108.1,33.82 v2(108.47,33.82) 108.56,33.82 108.72,33.66 108.72,33.18 ; v3(45.27,21.65) 44.99,21.65 44.87,21.52 v2(44.56,21.52) ; v2(14.21,32.24) 14.21,31.38 13.9,31.07 v3(13.9,30.54) 13.9,30.23 14.92,29.21 14.92,29.02 15.48,28.47 15.48,27.64 15.8,27.31 15.8,25.66 16.03,25.44 16.03,24.5 15.15,23.62 v3(15.15,23.35) 14.92,23.12 14.66,23.12 14.23,22.69 14.23,21.09 12.15,19.01 12.15,17.25 v3(12.28,17.13) 12.1,16.95 12.1,14.74 13.06,13.77 13.06,12.86 13.39,12.53 13.39,12.07 13.19,11.87 v3(11.95,11.87) ; v3(11.95,11.87) 11.82,11.74 10.8,11.74 9.71,12.83 v2(9.71,13.14) 9.71,13.16 9.41,13.47 9.41,13.77 9.61,13.98 10.93,13.98 v2(10.98,13.93) 11.46,13.44 v3(11.95,13.44) v3(11.95,11.87) ; v2(67.93,34.02) 67.9,33.99 67.75,33.99 67,33.24 66.35,33.24 65.72,32.62 64.36,32.62 63.69,33.29 63.69,33.95 v2(63.81,34.07) 64.04,34.29 66.56,34.29 67.49,35.23 70.3,35.23 70.96,34.58 71.99,34.58 v2(72.12,34.7) 72.14,34.7 72.45,34.4 72.73,34.4 72.96,34.17 74.76,32.37 v2(74.79,32.37) 74.79,32.34 75.29,31.83 75.29,30.44 75.57,30.16 v3(75.93,30.16) 76.11,30.16 76.41,30.46 76.92,30.46 77.3,30.84 77.58,30.84 77.86,30.56 77.86,29.32 78.19,28.99 78.19,28.25 77.91,27.97 v3(77.71,27.97) ; v2(13.98,28.1) 14.16,27.92 14.16,27.08 ; v3(69.28,34) 70.04,34 71.01,33.03 72.45,33.03 74.24,31.24 74.24,29.98 75.38,28.84 75.95,28.84 v3(76.09,28.7) 76.6,28.7 77.22,28.07 77.61,28.07 v3(77.71,27.97) ; v2(67.72,4.93) 67.72,5.01 v3(67.52,5.21) ; 102.85,42.41 102.98,42.54 102.98,43.31 103.36,43.69 104.6,43.69 104.66,43.63 ; v2(93.86,42.88) 93.86,42.43 ; v3(38.54,23.35) 38.64,23.25 39.58,23.25 v3(39.71,23.12) 39.99,23.4 39.99,24.72 42.28,27.01 42.28,27.38 44.73,29.83 47.69,29.83 49.58,27.95 v6(49.94,27.95) v6(50.67,27.95) 50.92,27.7 59.48,27.7 59.81,28.03 59.81,28.67 60.16,29.01 60.16,29.55 v3(60.69,30.08) 61.26,30.65 62.17,30.65 v6(62.31,30.79) 62.62,31.1 v6(62.98,31.1) 63.28,31.1 63.91,30.46 66.12,30.46 67.1,31.44 71.5,31.44 v2(71.7,31.24) 72.63,30.31 72.63,29.33 77.62,24.34 v2(77.76,24.34) 77.76,24.2 78.89,23.07 84.34,23.07 v3(84.62,23.35) 84.74,23.22 87.15,23.22 88.86,24.93 88.86,25.1 v2(88.83,25.13) 88.83,25.53 89.16,25.87 89.16,28.02 v3(89.44,28.3) ; v3(102.5,49.37) 102.8,49.37 102.85,49.31 102.95,49.31 102.99,49.27 v2(103.02,49.27) ; v3(18.45,41.89) 18.88,41.46 19.62,41.46 v3(21.17,39.91) 21.01,39.76 v2(21.01,39.45) 21,39.44 21,39.13 20.73,38.85 19.91,38.85 v2(19.87,38.89) 19.46,38.49 v3(19.03,38.49) 18.55,38.49 18.01,39.03 ; v3(50.63,23.63) 50.63,22.94 52.01,21.56 52.32,21.56 v3(52.48,21.39) 52.65,21.56 56.39,21.56 56.48,21.47 v2(56.76,21.47) 56.76,20.79 58.17,19.37 v2(58.17,19.13) ; 12.91,31.9 12.91,33.74 13.79,34.62 13.79,35.28 15.76,37.24 v3(15.76,37.57) ; v3(103.39,59.73) 104.07,59.73 104.5,59.3 104.5,59 104.39,58.88 v3(104.39,58.86) ; v3(71.33,30.59) 72.18,29.74 72.18,29.17 78.7,22.65 85.67,22.65 v3(85.71,22.61) 85.89,22.79 87.31,22.79 89.36,24.84 89.36,25.46 89.59,25.69 89.59,27.59 90.15,28.16 90.15,32.36 89.87,32.64 89.87,34.02 89.67,34.22 89.34,34.22 89.19,34.07 89.19,33.51 v3(89.39,33.31) 89.39,32.79 89.82,32.35 89.82,31.96 89.72,31.86 89.72,28.89 v2(89.52,28.68) ; 90.61,44.08 v3(90.61,43.65) ; 95.66,33.48 v2(95.61,33.43) 95.61,33.2 v3(95.44,33.03) 95.06,33.03 94.62,33.46 94.62,33.9 94.93,34.2 95.37,34.2 95.66,33.91 95.66,33.48 ; 56.42,23.83 55.59,23.83 55.53,23.78 55.53,23.32 55.76,23.09 58.1,23.09 58.2,22.99 60.05,22.99 60.38,23.32 v3(60.38,23.85) 60.17,24.06 56.75,24.06 v3(56.47,23.78) 56.42,23.83 ; v3(59.85,43.57) 59.98,43.69 60.77,43.69 61.02,43.44 61.02,43.34 61.3,43.06 v2(61.3,42.81) v3(61.3,42.4) 61.5,42.2 61.5,41 v3(61.08,40.58) 61.04,40.54 61.04,39.91 60.66,39.53 60.03,39.53 v2(59.93,39.63) 59.8,39.5 57.89,39.5 57.74,39.66 57.74,40.19 v3(58.29,40.73) 58.95,40.73 v3(59.01,40.67) 59.7,40.67 59.83,40.79 v2(59.83,41.66) 59.83,43.54 v3(59.85,43.57) ; 119.87,45.6 118.8,45.6 v3(118.52,45.32) 119.39,44.46 120.23,44.46 120.61,44.08 123.07,44.08 123.28,44.29 124.47,44.29 125.05,43.7 127.61,43.7 129.26,42.05 132.13,42.05 v3(132.44,41.74) 132.76,42.05 134.59,42.05 135.09,41.56 v3(135.62,41.56) 135.8,41.38 136.74,41.38 137.02,41.66 137.02,42.07 v3(137.04,42.09) 137.02,42.12 137.02,42.5 136.69,42.83 135.9,42.83 v3(135.75,42.68) 129.47,42.68 127.81,44.34 125.51,44.34 124.97,44.88 123.01,44.88 122.81,44.68 120.92,44.68 120.39,45.22 v2(120,45.22) 120,45.47 119.87,45.6 ; 56.62,13.49 54.95,13.49 54.64,13.19 v3(54.64,12.63) 54.64,12.6 54.8,12.44 56.25,12.44 56.73,12.92 56.73,13.19 v3(56.83,13.29) 56.62,13.49 ; 54.71,15.21 55.23,15.73 55.23,16.1 55.31,16.18 56.2,16.18 v2(56.48,15.9) 56.35,15.77 56.35,15.02 56.07,14.74 54.86,14.74 v3(54.71,14.89) 54.71,15.21 ; 94.85,40.6 v2(95.16,40.9) 94.83,41.23 94.27,41.23 93.94,40.9 v3(93.94,40.8) 94.14,40.6 94.85,40.6 ; 103.36,55.99 v3(102.92,55.55) 102.71,55.76 102.71,56.06 102.1,56.67 102.1,56.89 102.34,57.13 103.13,57.13 103.36,56.9 103.36,55.99 ; 44,5.26 44,4.88 44.18,4.71 v3(44.69,4.71) 44.79,4.81 44.79,5.19 45.07,5.47 45.07,5.98 v3(44.75,6.3) 44.56,6.48 v1(43.67,6.48) 43.29,6.1 43.29,5.85 43.67,5.47 43.8,5.47 44,5.26
  IN2 w0.06: v2(77.96,57.34) 78.09,57.47 78.09,58.31 79.43,59.65 ; v8(89.43,43.56) 89.23,43.36 89.23,43.29 89.24,43.29 89.24,42.31 89.11,42.18 88.91,42.18 88.83,42.11 88.83,41.82 88.55,41.54 v3(88.48,41.54) ; v8(85.83,42.36) 85.83,42.22 85.66,42.05 85.66,41.93 85.63,41.9 85.63,41.59 85.68,41.54 86.76,41.54 v3(86.84,41.62) ; 94.62,48.32 v2(94.52,48.32) 94.52,48.09 90.61,44.18 90.61,44.08 ; 88.84,40.98 88.86,41 88.88,40.98 ; 83.32,59.65 v2(83.57,59.65) v2(83.9,59.65) 84.08,59.65 ; v8(90.4,48.3) 90.61,48.5 91.2,48.5 91.3,48.39 v3(91.3,47.81) ; 95.07,42.53 94.87,42.32 94.14,42.32 93.84,42.02 v3(93.58,42.02) 93.58,42.15 93.86,42.43 ; 104.07,57.61 103.97,57.71 v3(102.78,57.71) ; v2(79.23,44.36) 79.23,44.36 78.11,45.48 ; 96.9,45.15 97.16,45.41 97.16,45.73 96.94,45.95 96.59,45.95 96.22,45.58 95.96,45.58 95.76,45.79 95.76,46.51 96.13,46.88 96.13,47.26 97.62,48.75 97.62,49.89 97.93,50.2 97.93,50.96 98.97,52 v2(98.97,52.15) 98.97,52.23 99.04,52.31 102.29,52.31 103.67,53.68 ; v3(97.36,47.12) 97.36,47.15 97.49,47.27 97.49,47.55 98.54,48.6 v3(98.54,49.06) 98.66,49.18 98.66,50.67 99.63,51.63 102.57,51.63 103.95,53.01 ; 78.11,51.99 78.32,52.2 v3(78.32,52.29) 78.31,52.29 ; 81.68,41.45 81.73,41.45 v8(81.83,41.56) ; 78.78,59.65 77.73,58.6 ; v8(92.35,49.1) 92.14,48.88 91.42,48.88 90.72,49.58 90.72,50.25 ; v2(93.86,42.88) 93.91,42.93 93.91,42.96 94.22,43.26 94.86,43.26 95.18,43.58 v3(95.18,44.08) 95.54,44.08 ; 105.73,32.54 105.85,32.66 105.85,33.28 105.68,33.45 ; 80.03,59.65 79.92,59.54 79.92,58.92 v3(79.94,58.89)
  IN2 w0.075: v3(93.29,38.08) 93.32,38.11 93.32,38.57 93.03,38.86 90.66,38.86 90.43,38.64 v3(90.38,38.64) ; v2(105.57,40.43) 105.52,40.48 105.03,40.48 104.88,40.32 103.67,40.32 102.5,41.49 v3(102.24,41.49) 102.14,41.49 101.18,42.45 101.18,42.86 101.55,43.23 v2(101.71,43.23) 102.03,43.23 102.85,42.41 v2(102.85,42.16) 102.85,41.95 103.8,41 104.52,41 v8(104.56,41.04) ; v3(78.32,52.29) 78.2,52.41 78.2,55.07 v3(78.63,55.5) 78.74,55.5 79.08,55.85 79.08,58.03 v3(79.94,58.89) 80.09,59.04 81.59,59.04 81.67,58.97 81.67,58.63 81.49,58.45 81.18,58.45 80.38,57.66 v8(80.38,56.05)
  IN2 w0.076: v3(105.62,41.45) v8(105.62,40.85)
  IN2 w0.152: v2(37.99,20.29) 37.99,20.32 v3(37.68,20.63) ; v3(37.73,16.41) 37.73,16.75 v2(38.01,17.04) ; v2(38.01,21.59) 38.01,21.89 38.18,22.06 38.18,22.99 v3(38.54,23.35) ; v3(37.7,18.67) 38.01,18.36 v2(38.01,18.33) ; v3(38.92,20.52) 38.69,20.29 v2(38.59,20.29) ; v2(38.66,17.04) v3(38.89,16.8) ; v3(77.88,39.38) 78.11,39.38 v2(78.22,39.26)
  IN2 w0.2: v3(86.93,49.54) 86.93,49.31 v8(87.13,49.11) ; v8(82.61,56.3) 82.61,56.19 v3(82.4,55.98) 81.67,55.98 v8(81.38,56.27) ; v8(89.06,49.45) 89.07,49.45 v3(89.45,49.45) ; v8(80.65,48.3) 80.65,48.01 v3(80.56,47.91) ; v8(83.83,41.96) 83.7,42.09 82.65,42.09 v3(82.51,41.95) ; v8(88.45,56.3) 88.81,55.95 89.34,55.95 v3(89.44,56.04) ; v8(82.61,54.7) 82.68,54.77 82.68,54.82 v3(82.88,55.01) ; v8(82.61,47.5) 82.56,47.45 v3(82.56,47.17) ; v3(84.07,41.17) 84.16,41.27 v8(84.16,41.58) ; v8(83.54,47.71) 83.35,47.9 v3(83.35,48.04) ; v8(89.75,50.7) 90.18,50.27 v3(90.7,50.27) 90.72,50.25 ; v3(82.77,37.67) 82.66,37.56 v8(82.24,37.56) ; v8(81.3,53.1) 81.3,52.87 v3(81.17,52.73) ; v3(88.76,35.13) 88.64,35.25 v8(88.64,35.56) v8(88.64,36.39) v8(88.64,36.76) ; v8(78.7,54.7) v3(78.7,54.3) ; v3(83.64,55.01) 83.83,54.82 83.83,54.77 v8(83.91,54.7) ; v8(80.65,53.89) 80.41,54.14 v3(80.41,54.22) ; v3(84.44,48.63) 84.56,48.51 v8(84.56,48.3) ; v3(81.18,51.03) 81.3,50.88 v8(81.3,50.7) ; v8(89.27,43.83) 89.27,44.11 92.88,47.72 92.88,48.16 93.12,48.4 93.56,48.4 93.63,48.47 94.38,48.47 v2(94.52,48.32) ; v3(88.67,52.75) 88.45,52.96 v8(88.45,53.1) ; v3(80,52.69) UD1.C8 v8(80,53.1) ; v3(82.61,52.69) 82.61,52.97 82.61,52.97 v8(82.61,53.1) ; v3(80.35,49.62) 80.62,49.89 v8(80.65,49.89)
  IN2 w0.203: v2(48.85,14.36) v3(49.14,14.06) ; v2(84.29,27.98) 85.03,27.98 v3(85.12,28.07) ; v2(121.06,35.41) 121.16,35.32 v3(121.16,35.05) ; v2(103.39,59.36) v3(103.39,59.73) ; v2(82.22,25.06) 82.93,25.06 v3(83.17,25.3) ; v3(18.27,43.25) 17.98,43.25 v2(17.92,43.19) ; v2(32.37,29.88) v3(32.77,29.88) ; v8(108.42,37.25) 108.71,37.25 108.89,37.07 v3(109.14,37.07) ; v2(95.11,9.32) 95.07,9.32 v3(94.86,9.54) ; v2(67.93,34.02) 68.32,34.02 v3(68.33,34) 68.77,34 v2(68.82,33.96) 69.22,33.96 69.26,34 v3(69.28,34) ; v2(38.94,12.58) 38.94,13.03 v3(39.07,13.16) ; v2(109.08,35.01) 109.05,35.01 108.97,35.09 108.62,35.09 v3(108.59,35.11) ; v8(87.16,54.7) 87.22,54.63 v3(87.93,54.63) 87.99,54.7 v8(88.45,54.7) ; v3(130.11,59.59) 130.01,59.49 v2(129.6,59.49) ; v3(11.29,35.77) 11.22,35.77 v2(10.9,36.08) ; v3(38.73,42.28) 38.73,42.21 v2(38.97,41.97) ; v3(119.53,30.83) 119.53,30.83 v2(119.53,30.38) ; v3(112.4,39.59) 112.4,39.66 112.66,39.91 112.84,39.91 v2(112.86,39.93) ; v2(142.71,21.66) 142.71,21.64 v3(142.93,21.42) ; v3(82.67,49.48) 82.61,49.42 v8(82.61,49.1) ; v3(145.25,19.1) v2(145.25,18.77) ; v2(34.61,28.79) v3(34.36,29.04) ; v8(89.43,37.56) 89.43,37.56 v3(89.08,37.56) 89.04,37.56 v8(88.64,37.96) ; v3(119.54,32.95) 119.46,32.87 v2(119.46,32.57) ; v3(89.44,28.3) 89.47,28.33 89.47,28.35 89.52,28.4 v2(89.52,28.68) ; v3(119.54,34.7) 119.54,35.11 v2(119.44,35.21) ; v2(50.45,21.47) 50.2,21.22 v3(50.15,21.22) ; v2(85.07,26.37) 84.42,25.72 v3(84.33,25.72) 84.33,25.63 84.13,25.43 v2(84.06,25.43) ; v2(8.47,31.38) v3(8.8,31.38) ; v2(30.93,43.94) 30.93,44.5 30.59,44.84 v3(30.41,44.84) ; v2(37.14,10.47) 37.32,10.47 v3(37.94,9.85) ; v2(11.54,23.02) 11.54,23.02 v3(11.79,22.76) ; v2(112.38,36.79) 112.17,36.79 112.1,36.86 v3(111.49,36.86) ; v3(106.35,59.72) 106.3,59.72 106.17,59.86 v2(105.97,59.86) ; v2(11.5,31.94) v3(11.2,32.23) ; v2(139.43,10.83) 139.78,10.83 v3(139.81,10.8) ; v2(146.67,40.17) 147.41,40.17 v3(147.79,40.54) ; v3(90.39,47.9) 90.4,47.91 v8(90.4,48.3) ; v2(43.01,4.83) 43.01,4.96 42.78,5.19 v3(42.78,5.34) ; v3(88.37,29.06) 88.2,28.89 88.2,28.82 v2(88.15,28.77) ; v3(148.86,40.49) v2(149.19,40.49) ; v3(108.49,35.95) 108.59,36.05 v2(108.82,36.05) ; v2(6.74,37.09) v3(6.41,37.09) ; v2(30.43,43.94) v3(30.43,44.27) ; v2(8.47,32.39) v3(8.8,32.39) ; v3(39.28,42.32) 39.38,42.22 v2(39.38,41.99) ; v3(106.92,57.11) 107.17,56.86 v2(107.39,56.86) ; v2(8.47,30.36) v3(8.8,30.36) ; v2(32.01,29.04) v3(31.63,29.04) ; v2(57.13,13.12) 56.96,13.29 v3(56.83,13.29) ; v2(8.1,27.06) v3(8.43,27.06) ; v3(149.61,48.06) v2(149.61,47.68) ; v3(146.13,47.68) 146.13,47.61 v2(146.34,47.4) ; v3(25.82,30.57) v2(25.82,30.9) ; v8(80,47.49) 79.88,47.37 v3(79.88,47.16) ; v2(123.33,18.68) 123.01,18.68 v3(123,18.68) ; v3(78.74,48.7) 78.7,48.73 v8(78.7,49.09) ; v3(39.48,39.68) v2(39.48,39.35) ; v2(17.92,43.97) 18.13,43.76 v3(18.18,43.76) ; v8(83.91,56.3) 83.91,56.19 v3(84.2,55.89) 84.56,55.54 v8(84.56,55.5) ; v3(80.31,25.42) 80.31,25.19 v2(80.17,25.05) ; v2(30.72,31.66) v3(30.72,31.33) ; v8(108.01,37.6) 107.98,37.64 107.74,37.64 107.7,37.68 v3(107.68,37.68) ; v8(81.83,42.36) v8(81.43,42.76) v8(81.43,43.16) 81.42,43.16 81.06,43.52 v3(81.06,43.55) ; v3(105.36,57.6) 105.36,57.88 v2(105.29,57.95) ; v3(38.46,39.5) v2(38.13,39.5) ; v2(8.48,33.41) v3(8.81,33.41) ; v3(59.09,16.8) v2(59.42,16.8) ; v2(9.16,37.09) v3(8.83,37.09) ; v3(148.31,36.44) 148.33,36.44 v2(148.58,36.69) ; v3(102.78,57.71) 102.54,57.71 v2(102.39,57.86) ; v3(91.3,47.81) 91.3,47.74 v8(91.05,47.5) ; v2(31.43,43.94) v3(31.43,44.27) ; v2(93.29,44.01) 92.81,44.01 v2(91.96,43.16) ; v2(98.48,9.12) 98.26,9.12 v3(98.16,9.23) ; v2(28.63,44.77) v3(28.9,45.03) ; v3(59.99,16.01) v2(60.32,16.01) ; v3(11.24,31.02) 11.24,31.16 11.47,31.4 v2(11.5,31.4) ; v2(141.46,21.6) 141.38,21.53 v3(141.38,21.19) ; v2(135.82,19.03) v3(136.25,19.03) ; v3(147.38,37.06) v2(147.38,37.63) ; v3(12.76,23.48) v2(12.3,23.02) ; v2(32.87,31.89) v3(33.2,31.89) ; v3(150.88,37.52) v2(150.88,37.19)
  IN2 w0.254: v2(104.89,60.83) 104.89,60.63 v3(104.75,60.49) ; v2(25.64,45.14) v3(25.64,45.5) ; v2(103.61,12.57) 104.2,12.57 v3(104.28,12.5) ; v2(74.43,5.77) 74.3,5.77 v3(74.13,5.59) ; v3(121.77,37.13) v2(121.77,37.5) ; v2(124.82,39.05) v3(125.09,39.31) ; v3(129.27,14.48) 129.01,14.74 v2(129.01,15.02) ; v3(143.37,8.22) v2(143.37,8.54) ; v3(24.27,9.89) 24.28,9.91 v2(24.28,10.65) ; v3(31.86,11.94) v2(31.86,11.05) ; v2(117.92,57.94) 118.49,57.94 v3(118.5,57.96) ; v3(148.9,47.71) 149.08,47.53 v2(149.08,47.07) ; v2(121.27,36.27) 121.53,36.53 121.56,36.53 v3(121.6,36.58) ; v2(20.34,6.47) v3(19.96,6.47) ; v3(118.5,57.19) 118.16,56.85 v2(117.94,56.85) ; v2(68.66,52.28) v3(69.2,52.28) ; v3(70.77,51.59) 70.92,51.45 v2(70.92,51.19) ; v2(105.39,34.96) 105.39,34.66 105.34,34.61 v3(105.34,34.56) ; v2(133.23,61.5) 132.72,61.5 v3(132.7,61.47) ; v2(114.31,47.71) 114.26,47.76 v3(114.26,48.05) ; v2(34.93,37.17) v3(34.93,37.52) ; v2(70.49,53.42) 70.95,53.42 v3(71.08,53.3) ; v3(55.35,36.38) 55.81,36.84 v2(56.12,36.84) ; v2(126.84,49.42) 126.87,49.42 127.08,49.21 v3(127.11,49.21) ; v2(11.5,29.24) 11.18,28.93 v3(11.18,28.84) ; v3(124.19,46.01) v2(124.19,46.39) ; v3(30.87,3.89) v2(30.87,3.54) ; v3(19.74,3.26) v2(19.49,3.51) ; v2(5.58,25.15) v3(5.58,24.77) ; v3(29.76,9.09) 29.41,9.44 v2(29.33,9.44) ; v3(17.2,5.11) v2(17.2,5.49) ; v2(122.76,57.99) 122.35,57.58 v3(122.35,57.55) ; v2(7.14,32.39) v3(7.14,32.77) ; v3(27.97,30.54) 28,30.54 28.08,30.46 28.28,30.46 v2(28.3,30.49) ; v2(113.01,35.82) 113.01,35.95 112.63,36.33 v3(112.1,36.33) ; v2(131.68,50.02) 131.71,49.99 v3(131.71,49.59) 131.71,49.47 132.02,49.16 v2(132.04,49.16) ; v6(53.37,42.88) 53.5,43 v2(54.38,43) ; v3(5.6,35.79) v2(5.88,36.07) ; v3(57.16,3.93) 57.26,3.84 v2(57.26,3.46) ; v3(121.01,48.14) 121.22,48.34 v2(121.22,48.55) ; v3(120.12,49.03) 119.68,49.03 v2(119.21,49.49) ; v2(72.09,36.43) 72.27,36.25 v3(72.27,35.72) 72.3,35.72 v2(72.75,35.26) ; v2(112.62,40.87) 112.62,41.03 112.73,41.14 v3(112.73,41.19) ; v3(30.01,34.55) v2(30.01,34.9) ; v3(18.25,2.27) v2(17.97,2.55) ; v2(109.89,43.77) 109.69,43.57 109.69,43.4 v3(109.63,43.35) ; v2(45.42,35.44) 45.42,35.31 v3(45.19,35.08) 44.99,35.29 v2(44.99,35.46) ; v3(131.48,53.04) 131.48,53.07 131.43,53.12 131.43,53.22 130.87,53.78 v2(130.87,54.36) ; v2(20.25,7.6) v3(19.92,7.6) ; v3(148.23,48.27) 148.23,47.67 v2(148.14,47.58) ; v2(65.58,6.53) 65.58,6.16 v3(65.69,6.05) ; v3(144.25,8.22) v2(144.25,8.54) ; v2(125.2,45.84) 125.07,45.71 v3(124.81,45.71) ; v2(122.66,24.09) 122.71,24.03 124.49,24.03 v3(124.57,23.96) ; v2(26.78,30.49) 26.81,30.46 27.03,30.46 27.08,30.51 27.16,30.51 v3(27.19,30.54) ; v3(28.41,14.57) 28.43,14.59 v2(28.43,14.89) ; v2(43.74,44.3) 43.61,44.43 v3(43.24,44.43) ; v3(30.21,47.63) v2(30.72,47.63) ; v3(127.64,51.09) 127.5,51.09 v2(127.34,50.92) ; v3(131.68,20.55) v2(131.3,20.55) ; v3(25.59,8.77) 25.76,8.94 v2(25.76,9.39) ; v3(71.16,40.61) 71.48,40.93 v2(71.48,41.04) ; v2(8.24,52.36) v3(8.24,51.95) ; v3(45.33,44.42) 45.16,44.42 45.13,44.45 v2(44.84,44.45) ; v2(119.48,31.63) 119.48,30.88 v3(119.53,30.83) ; v2(37.35,5.26) v3(37.35,5.68) ; v3(123.78,37.17) 123.73,37.12 v2(123.73,36.79) ; v3(12.94,15.47) v2(12.68,15.73) ; v3(93.72,35.38) 93.72,35.48 v2(93.32,35.88) 93.02,36.18 v2(93.02,36.53) ; v3(76.16,4.63) v2(76.16,5.01) ; v3(6.16,31.98) v2(6.16,32.37) ; v2(32.27,7.03) 32.27,6.58 v3(32.34,6.51) ; v3(118.5,58.97) 118.44,59.04 v2(117.94,59.04) ; v2(29.36,10.65) 30.13,9.89 v3(30.46,9.89) ; v3(25.59,9.86) 25.59,9.87 v2(25.59,10.65) ; v3(25.05,5.75) 25.04,5.73 v2(25.04,5.39) ; v2(124.29,64.19) v3(125.28,64.19) ; v2(56.46,7.7) 57.02,8.26 v3(57.03,8.26) ; v2(84.01,26.1) v3(83.73,25.82) ; v3(74.58,2.44) v2(74.85,2.71) ; v2(122.41,53.78) 123,53.78 v3(123.07,53.85) ; v3(115.62,41.09) v2(115.62,41.59) ; v3(31.45,44.79) v2(31.45,45.12) ; v2(131.7,51.47) 131.73,51.44 v3(131.73,51.06) 131.68,51.01 v2(131.68,50.65) ; v3(6.16,34.47) v2(6.16,34.85) ; v3(6.08,29.93) v2(6.08,30.31) ; v3(55.46,39.3) 55.38,39.3 55.28,39.2 v2(54.79,39.2) ; v3(35.44,9.81) 35.4,9.77 v2(35.04,9.77) ; v2(24.25,9.38) 24.25,9.32 24.8,8.77 v3(24.87,8.77) ; v3(145.14,8.22) v2(145.14,8.54) ; v3(62.09,2.42) v2(62.33,2.18) ; v3(33.23,7.14) 33.38,7.3 v2(33.38,7.64) ; v3(7.17,25.23) v2(6.92,25.48) ; v3(31.61,47.65) v2(31.21,47.65) ; v3(54.09,37.05) 54.09,37.04 54.14,36.99 54.14,36.61 v2(54.14,36.61) ; v2(47.48,39.73) v3(47.1,39.73) ; v3(27.67,47.5) v2(28.05,47.5) ; v3(11.06,14.51) v2(10.8,14.76) ; v2(24.24,14.77) 24.24,14.2 v3(24.06,14.03) ; v3(18.47,8.44) v2(18.22,8.69) ; v3(6.05,27.21) v2(6.05,27.59)
  IN2 w0.381: v3(131.9,28.84) v2(131.9,28.45) ; v2(9.73,22.71) v3(10.35,22.71)
  IN3 w0.076: 107.65,41.18 107.65,39.66 107.88,39.43 107.88,39.17 107.68,38.97 107.65,38.97
  IN3 w0.102: 76.45,18.19 76.45,18.54 69.61,25.38 65.01,25.38 v3(64.42,24.8) 63.89,25.33 62.52,25.33 61.86,24.67 61.86,23.73 v3(62.06,23.53) ; 76.45,18.19 76.8,18.19 77.42,17.58 84.27,17.58 84.51,17.33 v3(84.51,16.97) ; 76.45,18.19 76.18,17.92 76.18,16.19 76.54,15.83 v6(76.54,15.2) 76.56,15.17 77.22,15.17 v6(77.25,15.2) ; v3(19.03,38.49) 19.36,38.49 20.25,39.38 v3(20.25,43.61) 20.25,44.3 18.58,45.98 v3(18.47,45.98) 18.09,45.98 17.31,46.77 17.31,48.72 14.94,51.09 14.78,51.09 13.78,52.1 12.68,52.1 v3(12.15,51.57) 12.15,50.9 12.65,50.39 13.39,50.39 v3(13.67,50.68) 13.96,50.39 14.75,50.39 16.65,48.49 16.65,46.16 v3(16.92,45.88) 17.31,45.88 19.36,43.82 19.36,40.77 19.08,40.49 v3(19.08,40.27) 18.65,40.27 18.4,40.01 v3(18.27,40.01) ; v3(19.03,38.49) 18.02,37.47 v3(17.13,37.47) 15.86,37.47 v3(15.76,37.57) 15.76,37.24 15.65,37.14 13.6,37.14 12.23,35.77 v3(11.29,35.77) 11.29,32.54 11.2,32.46 v3(11.2,32.23) 11.24,32.2 v3(11.24,31.02) 11.12,30.9 11.12,28.9 v3(11.18,28.84) 11.18,28.77 11.41,28.54 11.41,26.62 12.76,25.28 v3(12.76,23.48) 12.76,21.04 14.38,19.41 14.38,19.06 15.96,17.48 15.96,14.46 v3(17.65,12.77) 17.65,12.67 18.25,12.07 31.73,12.07 v3(31.86,11.94) 32.14,12.22 40.52,12.22 v3(40.75,12.45) 40.95,12.66 45.47,12.66 v3(45.68,12.45) 45.98,12.15 47.23,12.15 48.06,11.31 49,11.31 49.56,10.75 51.24,10.75 53.32,12.83 53.32,13.34 ; v3(19.03,38.49) 18.4,38.49 18.02,38.87 18.02,39.76 v3(18.27,40.01) ; v6(19.24,28.78) 19.52,29.06 20.46,29.06 v6(20.81,28.71) 21.27,28.71 21.67,28.3 v3(21.78,28.3) 22.03,28.05 v3(22.03,27.41) ; v6(19.24,28.78) 19.16,28.71 18.4,28.71 18.09,28.4 18.09,27.69 ; v6(19.24,28.78) 18.93,29.09 18.45,29.09 18.17,29.37 18.17,29.8 v3(17.97,30) 17.57,30.4 v3(16.81,30.4) ; v6(19.24,28.78) 19.64,28.78 19.92,28.5 19.92,27.62 20.47,27.06 20.47,26.39 19.48,25.4 19.48,24.33 19.03,23.88 v3(19.03,23.6) 19.29,23.35 19.4,23.35 20.67,22.08 v3(20.67,21.86) ; 84.46,15.63 84.44,15.65 82.61,15.65 81.95,14.99 78.88,14.99 v6(78.67,15.2) v6(77.96,15.2) v6(77.25,15.2) ; 84.46,15.63 84.92,16.08 88.48,16.08 89.39,15.17 v3(89.39,15.09) 90.26,15.09 90.79,14.56 v3(90.79,14.26) ; 84.46,15.63 84.46,15.09 84.56,14.99 87.56,14.99 88.73,13.81 90.35,13.81 v3(90.79,14.26) ; v3(93.29,38.08) 92.97,38.08 92.9,38.01 92.11,38.01 ; v3(93.29,38.08) 93.31,38.09 93.31,38.7 93.51,38.89 94.85,38.89 97.02,36.72 ; v3(93.29,38.08) 93.29,37.94 93.61,37.62 94.83,37.62 95.92,36.53 v3(95.92,36.31) 95.92,35.64 96.91,34.65 96.91,27.75 94.61,25.45 90.81,25.45 89.61,24.26 84.18,24.26 83.52,23.6 79.96,23.6 74.94,28.62 74.94,28.96 73.99,29.9 73.99,32.21 73.75,32.45 73.75,40.73 73.31,41.18 72.3,41.18 71.08,42.4 v3(70.75,42.4) ; v3(17.48,24.72) 17.43,24.72 16.79,25.36 16.79,27.32 16.38,27.73 v3(15.88,27.73) ; v3(17.48,24.72) 17.25,24.49 17.25,20.68 ; v3(17.48,24.72) 17.74,24.72 18.15,25.13 18.15,26.3 17.92,26.53 v3(17.68,26.53) 17.68,27.29 18.09,27.69 ; v3(61.3,42.4) 61.3,42.32 61.5,42.12 61.5,41 v3(61.08,40.58) 60.82,40.32 60.82,38.77 59.8,37.75 57.16,37.75 56.42,37.01 56.42,36.53 v3(56.65,36.3) 56.65,36.12 55.58,35.06 52.79,35.06 52.43,34.7 46.52,34.7 46.36,34.85 46.36,35.29 46.19,35.46 45.58,35.46 v3(45.19,35.08) 44.86,35.41 43.59,35.41 43.04,34.85 v3(42.86,34.85) 42.86,34.63 42.45,34.22 41.28,34.22 40.93,34.57 40.93,35.85 v3(41.05,35.97) ; v3(61.3,42.4) 60.74,42.96 60.74,43.39 60.56,43.57 v3(59.85,43.57) 59.24,42.96 59.24,40.9 v3(59.01,40.67) ; v3(61.3,42.4) 60.92,42.4 60.74,42.22 60.71,42.22 60.05,41.56 60.05,39.53 59.06,38.53 56.97,38.53 55.35,36.91 v3(55.35,36.38) 55.35,36.33 55.14,36.11 41.67,36.11 41.54,35.97 v3(41.05,35.97) ; v3(92.41,12.17) 92.41,12.93 92.69,13.21 95.66,13.21 96.3,12.58 97.72,12.58 v6(98.2,12.1) ; v3(92.41,12.17) 92.06,12.17 91.2,13.03 88.42,13.03 87.28,14.16 75.7,14.16 75.4,14.45 75.4,18.46 72.29,21.57 71.46,21.57 v3(71.38,21.65) 70.93,22.1 69.86,22.1 69.53,21.77 v3(69.53,21.6) ; v3(92.41,12.17) 92.41,11.87 92.8,11.49 97.6,11.49 v6(98.2,12.1) ; v3(42.27,37.6) 35.01,37.6 v3(34.93,37.52) 34.4,36.99 v3(34.4,36.94) ; v3(42.27,37.6) 43.08,36.79 53.64,36.79 53.89,37.04 54.08,37.04 v3(54.09,37.05) 54.11,37.04 54.57,37.04 56.71,39.18 58.56,39.18 59.27,39.88 59.27,40.42 v3(59.01,40.67) ; v3(42.27,37.6) 42.27,37.98 42.68,38.39 43.9,38.39 v3(44.31,37.98) 44.84,37.45 53.15,37.45 53.92,38.22 54.44,38.22 54.47,38.25 v3(54.47,38.25) 54.47,38.32 55.44,39.3 v3(55.46,39.3) 55.46,41.76 56.32,42.63 56.73,42.63 57.31,42.04 57.31,41.66 56.73,41.08 56.73,40.19 57.08,39.83 57.59,39.83 57.74,39.99 57.74,40.39 58.09,40.73 v3(58.29,40.73) 58.95,40.73 v3(59.01,40.67) ; 92.11,38.01 91.93,38.19 91.93,38.72 92.71,39.49 95.09,39.49 98.48,36.1 98.48,34.75 98.11,34.38 98.11,30.63 v3(98.41,30.33) 98.41,30 98.11,29.7 98.11,27.3 95.1,24.28 91.29,24.28 90.1,23.09 86.16,23.09 85.71,22.64 v3(85.71,22.61) 85.43,22.33 79.38,22.33 73.54,28.17 73.54,28.7 72.54,29.7 72.54,31.18 72.27,31.45 72.27,35.72 v3(72.27,35.72) 72.07,35.72 71.24,36.54 71.24,37.91 69.45,39.7 v3(69.45,40.32) 69.45,40.49 69.58,40.62 69.58,41.88 69.23,42.23 68.87,42.23 68.78,42.14 v3(68.44,42.14) ; 92.11,38.01 91.9,37.81 91.9,37.66 92.53,37.04 94.55,37.04 95.03,36.56 95.03,35.67 96.32,34.37 96.32,27.99 94.37,26.03 90.56,26.03 89.37,24.84 83.94,24.84 83.28,24.18 80.28,24.18 76.09,28.36 v3(76.09,28.7) 75.99,28.7 75.55,29.14 75.55,29.17 74.6,30.12 74.6,32.44 74.34,32.71 74.34,41.76 73.21,42.88 72.98,42.88 72.65,43.21 72.12,43.21 71.62,43.71 71.23,43.71 v3(71,43.94) 71.12,44.06 71.12,44.14 71.92,44.94 v3(72.55,44.94) ; 50.71,11.46 51.54,12.3 51.54,12.58 v3(50.78,13.34) 51.04,13.6 53.07,13.6 53.32,13.34 ; v3(95.44,29.72) 95.72,29.45 95.72,28.21 94.21,26.7 90.26,26.7 88.99,25.43 84.62,25.43 v3(84.33,25.72) ; v3(95.44,29.72) 95.72,30 95.72,32.75 v3(95.44,33.03) 95.72,33.31 95.72,34.05 93.39,36.38 92.12,36.38 91.78,36.72 91.26,36.72 90.38,37.6 v3(90.38,38.64) 90.78,39.04 91.07,39.04 92.01,39.97 v3(92.01,40.04) 92.08,40.12 95.38,40.12 97.9,37.6 98.16,37.6 99.17,36.59 99.17,35.44 99.14,35.41 99.14,34.27 98.99,34.12 v3(98.99,33.94) 99.04,33.89 v3(99.04,33.48) 99.04,33.26 99.3,33.01 99.3,32.01 99.68,31.63 99.68,29.65 99.06,29.03 99.06,27.42 95.31,23.67 91.51,23.67 90.34,22.5 87.03,22.5 86.11,21.59 79.08,21.59 72.63,28.04 72.63,28.79 71.96,29.46 71.96,29.96 v3(71.33,30.59) 71.36,30.61 71.36,31.12 71.56,31.32 71.56,35.19 70.61,36.14 70.61,37.67 67.85,40.43 v3(67.85,40.8) 67.85,41.17 68.44,41.75 v3(68.44,42.14) ; v3(95.44,29.72) 94.8,29.09 94.8,28.21 94.46,27.87 v3(94.37,27.87) 94.37,27.77 93.84,27.23 90.08,27.23 88.78,25.94 86.27,25.94 85.86,26.35 85.08,26.35 84.45,25.72 v3(84.33,25.72) ; 43.05,27.39 43.05,26.92 45.17,24.8 45.17,21.75 v3(45.27,21.65) 45.53,21.65 46.13,21.04 46.62,21.04 47.13,21.55 47.13,22.36 ; v3(37.57,35.06) 37.65,35.13 37.78,35.13 37.85,35.21 38.41,35.21 39.45,34.17 39.45,31.49 41.87,29.07 v3(41.87,28.33) 41.87,26.98 44.26,24.6 44.26,20.99 44.84,20.4 v3(45.17,20.4) 45.4,20.17 49.33,20.17 50.1,20.94 50.1,21.11 50.15,21.16 v3(50.15,21.22) 50.2,21.22 v2(50.45,21.47) 52.41,21.47 v3(52.48,21.39) 52.78,21.09 56.14,21.09 56.73,20.5 60.51,20.5 61.88,21.88 63.98,21.88 64.47,22.37 v3(64.47,23.09) ; v3(37.57,35.06) 37.57,35.24 37.47,35.34 34.23,35.34 30.98,38.59 v3(30.08,38.59) 29.65,38.59 29.47,38.41 26.61,38.41 v3(26.5,38.52) 25.39,39.63 24.98,39.63 24.72,39.88 v3(24.62,39.88) ; v3(37.57,35.06) 37.57,34.02 37.93,33.66 38.44,33.66 v3(38.46,33.64) 38.46,30.92 40.47,28.91 v6(40.55,28.91) v6(40.55,27.46) 40.55,27.18 43.44,24.29 43.44,20.67 44.1,20.01 v3(44.1,19.74) 44.49,19.35 49.73,19.35 50.69,20.31 55.57,20.31 55.96,19.92 v3(55.96,19.84) 56.12,19.69 61.32,19.69 v3(62.09,20.45) 62.72,21.08 64.37,21.08 65.49,22.21 65.49,23.12 65.74,23.37 69.43,23.37 v3(69.55,23.25) ; v3(84.33,25.72) 83.82,25.72 v3(83.73,25.82) 83.62,25.82 83.17,25.37 v3(83.17,25.3) 83.17,25.08 82.91,24.82 81.06,24.82 80.46,25.42 v3(80.31,25.42) 79.86,25.42 77.71,27.58 v3(77.71,27.97) 77.71,28.05 77.33,28.42 77.25,28.42 77.15,28.52 77.15,28.94 v3(75.93,30.16) ; v3(65.69,6.05) 65.59,5.95 65.59,5.49 v3(65.21,5.11) 62.82,5.11 61.86,4.15 57.37,4.15 v3(57.16,3.93) 57.16,3.94 57.14,3.94 57.05,4.02 54.69,4.02 v3(54.62,3.94) 54.39,3.71 35.14,3.71 v3(34.91,3.94) v3(32.34,6.51) v3(29.76,9.09) 29.62,9.23 27.21,9.23 26.75,8.77 v3(25.59,8.77) 25.56,8.74 24.9,8.74 v3(24.87,8.77) 24.67,8.97 21.57,8.97 21.38,8.78 v3(20.11,8.78) 16.56,8.78 13.47,11.87 v3(11.95,11.87) 11.82,11.74 11.39,11.74 11.01,12.12 11.01,13.14 11.31,13.44 v3(11.95,13.44) 12.81,13.44 16.54,9.71 20.23,9.71 v3(20.36,9.84) 21.04,9.84 21.09,9.89 v3(24.27,9.89) 25.56,9.89 v3(25.59,9.86) 25.76,10.04 30.31,10.04 v3(30.46,9.89) 33.21,7.14 v3(33.23,7.14) v3(34.27,6.1) 36.01,4.36 41.38,4.36 41.75,4.73 v3(42.07,4.73) 44.66,4.73 v3(44.69,4.71) 44.81,4.58 44.94,4.58 45.14,4.37 49.31,4.37 v3(49.51,4.58) 49.72,4.37 51.27,4.37 v3(51.47,4.58) 51.67,4.37 53.83,4.37 ; v3(65.69,6.05) 65.95,5.8 66.94,5.8 v3(67.52,5.21) 67.65,5.09 68.84,5.09 69.15,5.39 69.15,5.68 68.35,6.48 66.58,6.48 65.77,7.3 v3(65.77,7.91) 65.57,7.91 64.98,8.49 63.63,8.49 62.9,7.76 59.51,7.76 59.24,8.03 57.26,8.03 v3(57.03,8.26) 56.86,8.09 55.92,8.09 55.7,8.31 55,8.31 54.29,9.02 v3(54.11,9.02) 53.5,9.63 48.7,9.63 47.2,11.13 45.6,11.13 44.89,11.84 41.51,11.84 41.18,11.51 39.25,11.51 v3(38.97,11.23) 38.57,10.83 35.72,10.83 v3(35.52,11.03) 35.24,10.75 31.71,10.75 31.1,11.36 16.77,11.36 12.58,15.55 v6(12.58,16.26) 11.9,16.26 11.57,16.59 11.57,22.54 v3(11.79,22.76) 10.93,23.63 10.24,23.63 8.62,25.25 7.93,25.25 7.53,24.85 7.53,24.39 8.21,23.7 9.15,23.7 10.14,22.71 v3(10.35,22.71) 10.83,22.23 10.83,16.29 16.47,10.65 16.75,10.65 v3(16.92,10.47) 17.1,10.65 30.79,10.65 31.38,10.06 35.19,10.06 v3(35.44,9.81) 35.69,10.06 37.73,10.06 v3(37.94,9.85) 38.91,9.85 39.89,10.83 41.72,10.83 41.92,11.03 44.56,11.03 45.22,10.37 46.95,10.37 48.42,8.9 52.94,8.9 53.75,8.08 54.03,8.08 54.49,7.63 55.41,7.63 55.76,7.27 58.68,7.27 v3(58.89,7.07) 63.49,7.07 v3(63.86,7.44) 64.1,7.68 64.68,7.68 64.98,7.37 64.98,6.76 ; v3(65.69,6.05) 64.98,6.76 ; v3(69.55,23.25) 69.65,23.25 69.85,23.45 69.85,24.03 69.29,24.59 68,24.59 v3(67.78,24.36) 67.57,24.16 65.39,24.16 64.47,23.25 v3(64.47,23.09) ; v3(69.55,23.25) 69.55,23.21 69.38,23.03 69.38,21.75 v3(69.53,21.6) ; v3(117.43,34.07) 117.23,33.86 117.23,32.98 116.75,32.49 116.75,30.49 117.1,30.13 ; v3(117.43,34.07) 117.71,34.35 117.71,35.06 117.46,35.31 v3(116.82,35.31) ; v3(117.43,34.07) 117.74,33.76 117.74,31.12 117.1,30.49 117.1,30.13 ; 14.59,22.66 14.59,23.12 14.82,23.35 v3(15.15,23.35) ; 14.59,22.66 14.94,22.66 v3(15.6,22) v3(16.67,20.94) 16.92,20.68 17.25,20.68 ; 14.59,22.66 14.18,22.26 14.18,21.77 14.66,21.29 14.82,21.29 16.65,19.46 19.79,19.46 20.94,18.32 20.94,17.07 21.7,16.31 22.41,16.31 v3(22.51,16.21) 22.61,16.31 23.18,16.31 23.71,16.85 24.42,16.85 24.62,16.64 26.2,16.64 27.75,18.19 v6(28.33,18.19) 28.33,20.17 30.03,21.88 30.03,25.05 30.31,25.33 30.31,25.76 30.06,26.02 29.57,26.02 29.22,25.66 29.22,24.29 v6(28.79,23.86) 29.22,23.42 29.22,22.51 v6(28.43,21.72) 27.39,20.68 27.39,19.26 v3(26.48,18.34) 26.17,18.04 26.17,17.84 25.79,17.46 25.1,17.46 24.9,17.66 23.37,17.66 22.96,17.25 22.06,17.25 21.75,17.56 21.75,18.85 v3(20.23,20.38) 19.45,20.38 v3(18.96,20.87) ; v3(116.82,35.31) 116.67,35.15 116.67,33.15 116.24,32.73 116.24,30.18 116.59,29.83 116.59,29.1 115.6,28.11 115.6,26.64 v3(115.49,26.53) 115.6,26.42 115.6,24.03 114.7,23.12 v3(114.41,23.12) 114.38,23.09 114.38,22.97 114.05,22.64 114.05,18.57 112.71,17.23 112.6,17.23 111.41,16.03 v3(110.85,16.03) 110.52,16.03 109.41,14.92 101.71,14.92 101.41,14.61 v3(99.68,14.61) 99.47,14.41 96.44,14.41 96.23,14.62 92.43,14.62 91.98,15.07 v3(91.6,15.07) 91.6,15.09 90.43,16.26 v6(90.43,16.47) v6(89.72,16.47) 89.26,16.47 v6(89.04,16.69) ; v3(116.82,35.31) 116.52,35.62 116.52,37.14 v3(116.75,37.37) ; v3(39.23,36.57) 38.91,36.89 36.66,36.89 36.56,36.79 v3(36.56,36.63) 36.53,36.61 36.41,36.61 35.92,36.12 34.86,36.12 34.4,36.58 v3(34.4,36.94) ; v3(39.23,36.57) 39.23,35.53 40.32,34.45 40.32,31.73 43.07,28.98 43.07,28.36 ; v3(39.23,36.57) 39.51,36.84 40.19,36.84 v3(41.05,35.97) ; v3(15.87,36.16) 16.14,36.43 18.12,36.43 ; v3(15.87,36.16) 13.55,33.84 13.55,30.89 v3(13.9,30.54) 14.18,30.26 14.92,30.26 15.44,30.78 15.44,32.65 v3(14.77,33.32) 14.84,33.38 15.22,33.38 16.33,34.49 16.33,34.74 16.95,35.36 18.32,35.36 v3(18.47,35.21) 18.8,35.53 20.91,35.53 21.77,36.4 24.23,36.4 v3(24.54,36.71) 24.62,36.71 25.69,37.78 25.69,38.54 24.57,39.66 24.57,39.83 v3(24.62,39.88) ; v3(15.87,36.16) 15.77,36.26 13.69,36.26 12.43,35 v3(12.43,33.43) v3(12.43,27.84) 12.43,27.49 13.72,26.19 13.72,22.92 13.42,22.61 13.42,21.36 v3(15.3,19.49) 16.92,17.86 v3(16.92,16.01) 16.92,14.59 17.64,13.87 17.94,13.87 v3(18.86,12.96) 19.13,12.68 28.23,12.68 28.5,12.95 v3(28.51,12.95) 38.86,12.95 v3(39.07,13.16) 39.38,13.16 39.68,13.47 46.31,13.47 v3(46.74,13.04) 47.28,13.04 48.37,11.94 49.39,11.94 49.89,11.44 50.71,11.44 ; v3(68.44,42.14) 68.44,42.8 68.46,42.82 68.46,45.14 v3(68.49,45.17) 68.46,45.19 68.46,46.56 68.99,47.1 v3(69.1,47.1) 69.43,47.1 70.34,46.18 70.34,45.62 v3(70.39,45.57) ; v3(19.92,37.09) 21.19,37.09 v3(21.57,37.47) ; v3(19.92,37.09) 19.82,37.2 18.88,37.2 18.12,36.43 ; v3(19.92,37.09) 20,37.01 20,36.4 19.71,36.12 18.43,36.12 18.12,36.43 ; v6(67.06,26.93) 66.81,26.93 65.9,27.84 65.9,33.54 65.52,33.92 63.91,33.92 62.47,32.47 62.47,31.61 v6(62.98,31.1) 63.21,30.87 63.51,30.87 63.84,30.54 63.84,28.62 v6(63.44,28.21) 63.17,27.95 61.54,27.95 57.73,24.14 56.88,24.14 56.52,23.78 v3(56.47,23.78) ; v6(67.06,26.93) v6(68.46,26.93) v6(69.53,26.93) 69.6,26.85 69.94,26.85 77.94,18.85 85.46,18.85 86.09,18.22 87.87,18.22 88.97,19.32 91.51,19.32 92.81,20.62 98.53,20.62 100.06,22.15 v3(100.19,22.15) 100.16,22.18 100.16,22.33 100.74,22.92 102.95,22.92 103.31,22.56 v3(103.31,22.33) 103.31,22.15 102.88,21.72 102.45,21.72 101.36,20.63 100.9,20.63 100.33,20.06 v6(100.14,20.06) 100.04,20.06 99.86,19.88 99.59,19.88 99.04,19.34 96.05,19.34 v6(95.79,19.08) v6(95.08,19.08) 94.83,19.34 93.32,19.34 92.04,18.05 89.63,18.05 89.04,17.46 v6(89.04,16.69) ; v6(67.06,26.93) 66.81,26.68 62.07,26.68 60.38,24.99 v3(60.38,23.85) 60.38,23.45 59.77,22.84 57.44,22.84 57.13,23.15 56.8,23.15 56.47,23.48 v3(56.47,23.78) ; v3(69.53,21.6) 69.53,20.99 69.96,20.55 72.17,20.55 73.25,19.48 v3(73.25,19.17) 73.58,19.17 74.62,18.13 74.62,14.01 75.12,13.51 75.25,13.38 86.94,13.38 88.1,12.22 90.43,12.22 v3(90.78,11.88) 91.95,10.7 98.46,10.7 99.65,11.89 103.02,11.89 103.63,12.5 104.27,12.5 v3(104.28,12.5) 104.28,12.5 110.9,12.5 113.17,14.76 v3(113.44,14.76) 113.64,14.96 114.79,14.96 117.15,17.33 117.15,19.51 v3(117.33,19.69) 117.33,21.98 117.8,22.45 117.8,26.33 118.74,27.27 118.74,29.31 119.31,29.88 119.31,30.61 v3(119.53,30.83) 119.53,32.94 v3(119.54,32.95) v3(119.54,34.7) 119.54,38.97 120.83,40.26 120.83,46.62 120.56,46.89 120.56,48.44 120.12,48.88 v3(120.12,49.03) 120,49.03 119.57,49.46 119.57,52.49 ; 97.6,35.31 97.11,35.31 96.86,35.57 96.86,36.56 97.02,36.72 ; 97.6,35.31 97.77,35.13 97.77,34.93 97.52,34.68 97.52,27.54 94.85,24.87 91.05,24.87 89.85,23.67 85.04,23.67 84.72,23.35 v3(84.62,23.35) 84.28,23.01 79.72,23.01 74.25,28.47 74.25,28.82 73.36,29.71 73.36,31.88 73.16,32.09 73.16,36.55 72.25,37.45 v6(72.25,37.75) 71.93,38.08 71.9,38.08 70.37,39.61 70.37,40.09 70.71,40.43 70.98,40.43 v3(71.16,40.61) 71.08,40.69 70.68,40.69 70.3,41.07 70.3,41.95 v3(70.75,42.4) ; 97.6,35.31 97.77,35.49 97.77,35.97 97.02,36.72 ; v3(24.62,39.88) v3(24.62,41.03) 24.82,41.23 25.38,41.23 27.2,39.41 v3(28.85,39.41) 29.15,39.71 31.33,39.71 34.1,36.94 v3(34.4,36.94) ; v3(115.3,57.38) 115.3,57.66 112.36,60.61 v3(112.36,61.83) ; v3(115.3,57.38) 115.63,57.05 115.63,56.34 117.28,54.69 117.28,53.35 v3(118.27,52.36) ; v3(115.3,57.38) 115.2,57.28 115.02,57.28 114.66,56.93 114.66,56.59 116.77,54.48 116.77,50.52 117.41,49.88 117.41,48.48 118.48,47.41 118.48,45.51 118.52,45.47 v3(118.52,45.32) 118.74,45.11 118.74,41.43 117.2,39.9 117.2,39.13 116.75,38.67 v3(116.75,37.37) ; v3(90.79,14.26) 91.04,14.01 95.98,14.01 96.26,13.72 101.62,13.72 v3(101.99,14.09) 102.21,14.31 109.61,14.31 110.4,15.09 v3(110.7,15.09) 111.21,15.09 112.84,16.72 112.96,16.72 114.99,18.75 114.99,22.01 116.21,23.23 116.21,27.31 v6(116.46,27.57) 116.46,28.13 117.1,28.77 117.1,30.13 ; v3(128.91,60.2) 128.91,59.98 128.09,59.16 v3(128.09,58.83) 128.09,58.66 134.13,52.62 134.13,47.14 v3(134.07,47.07) 134.15,47 134.15,43.44 134.91,42.68 v3(135.75,42.68) 135.95,42.88 136.81,42.88 137.04,42.65 v3(137.04,42.09) 137.04,41.66 136.71,41.33 135.85,41.33 v3(135.62,41.56) 135.13,41.56 133.51,43.17 133.51,46.31 133.21,46.62 133.21,48.77 133.49,49.05 133.49,52.36 127.94,57.91 127.25,57.91 127.08,58.07 127.08,59.09 127.85,59.85 127.85,60.31 127.26,60.89 127.26,63.02 127.87,63.63 127.87,64.52 v3(127.11,65.28) 126.98,65.16 126.35,65.16 124.7,66.81 v3(124.7,67.19) 124.9,67.39 126.4,67.39 v3(126.6,67.19) 128.53,65.26 128.53,62.79 128.89,62.44 ; v3(128.91,60.2) 128.89,60.2 128.38,60.71 128.38,61.93 128.89,62.44 ; v3(128.91,60.2) 129.04,60.33 130.03,60.33 v3(130.28,60.59) 130.28,60.97 130.95,61.63 132.55,61.63 v3(132.7,61.47) 132.85,61.63 137.12,61.63 v3(137.42,61.32) ; v3(118.27,52.36) 118.25,52.33 117.97,52.33 117.3,51.66 117.3,50.71 117.94,50.07 117.94,48.67 118.99,47.62 118.99,45.86 119.25,45.61 119.25,41.22 117.74,39.71 117.74,36.76 117.5,36.52 117.01,36.52 116.75,36.79 v3(116.75,37.37) ; v3(118.27,52.36) 118.5,52.36 118.76,52.1 118.76,48.99 119.77,47.98 119.77,46.25 120.03,45.99 120.03,40.89 118.53,39.39 118.53,30.49 v3(118.32,30.28) 117.92,29.88 117.92,27.55 117,26.63 117,22.89 116.33,22.22 116.33,18.39 113.93,15.98 v3(113.64,15.98) 113.56,15.91 113.17,15.91 110.76,13.5 103.1,13.5 v3(102.81,13.21) 102.38,12.78 98.89,12.78 v6(98.2,12.1) ; v3(21.9,24.06) 22.64,23.32 22.64,22.08 v3(21.9,21.34) 21.57,21.67 20.86,21.67 v3(20.67,21.86) ; v3(21.9,24.06) 21.67,24.06 21.14,23.53 21.14,23.3 21.01,23.17 20.42,23.17 20.07,23.52 20.07,24.66 20.28,24.87 v3(20.99,24.87) 20.97,24.9 20.97,24.9 21.24,25.18 21.24,26.02 21.67,26.45 v3(21.9,26.45) 22.03,26.57 v3(22.03,27.41) ; v3(21.9,24.06) 22.11,24.26 22.11,25.33 22.37,25.6 23.29,25.6 ; v3(64.47,23.09) 63.97,23.6 62.14,23.6 v3(62.06,23.53) ; 107.65,38.97 107.25,38.97 106.84,39.38 106.84,39.58 106.52,39.9 106.52,40.1 106.84,40.42 106.84,40.7 106.64,40.9 106.23,40.9 105.93,40.6 104.83,40.6 104.43,40.19 101.31,40.19 v3(101.22,40.09) 100.89,40.42 97.16,40.42 96.43,41.15 95.82,41.15 95.11,40.44 94.29,40.44 v3(93.94,40.8) 93.94,40.82 94.5,41.38 94.75,41.38 94.9,41.54 94.9,42.22 95.16,42.47 95.56,42.47 96.12,41.92 96.81,41.92 97.52,41.2 101.96,41.2 v3(102.24,41.49) 102.78,40.95 104.1,40.95 104.4,41.26 105.43,41.26 v3(105.62,41.45) 105.79,41.61 107.04,41.61 107.35,41.31 v3(107.55,41.31) 107.65,41.2 107.65,41.18 ; v3(20.67,21.86) 19.9,21.09 19.18,21.09 v3(18.96,20.87) ; v3(70.39,45.57) 70.39,45.45 69.26,44.32 69.26,43.15 70.01,42.4 v3(70.75,42.4) ; v3(70.39,45.57) 70.47,45.65 71.84,45.65 v3(72.55,44.94) ; 23.3,25.58 23.73,26.02 23.73,27.31 23.33,27.72 22.33,27.72 v3(22.03,27.41) ; v3(21.65,47.05) 20.4,47.05 19.58,47.86 ; 47.13,22.36 v3(47.13,22.46) 46.85,22.74 46.85,23.22 v3(46.39,23.68) 46.85,24.14 47.23,24.14 48.81,25.72 55.27,25.72 56.29,24.69 56.29,23.96 v3(56.47,23.78) ; 47.13,22.36 48.31,21.18 v3(48.94,21.18) 48.94,21.89 50.35,23.3 50.35,23.35 v3(50.63,23.63) ; v6(77.25,15.2) 77.25,15.55 77.96,16.26 78.85,16.26 79.24,15.87 v3(79.4,15.87) 79.5,15.87 79.76,15.6 81.69,15.6 82.36,16.26 84.11,16.26 84.51,16.67 v3(84.51,16.97) ; 18.09,27.69 18.83,27.69 19.32,27.2 19.32,26.68 18.73,26.09 18.73,24.7 18.04,24.01 18.04,22.89 v3(18.47,22.46) 18.7,22.23 18.7,21.12 v3(18.96,20.87) ; v6(23.1,37.47) 23.86,37.47 v3(24.6,38.21) 24.6,38.44 22.98,40.06 22.98,42.15 v3(23.27,42.45) ; v6(23.1,37.47) 22.84,37.73 22.84,37.98 22.77,38.06 v3(22.77,38.82) 22.33,39.25 22.33,44.71 21.89,45.15 v3(21.89,45.52) 21.53,45.52 21.19,45.86 20.76,45.86 18.68,47.94 18.68,49.05 16.7,51.03 16.7,52.46 16.01,53.14 v3(15.32,53.14) 15.32,53.42 16.26,54.36 v3(16.92,54.36) ; v6(23.1,37.47) v3(21.57,37.47) ; v3(17,44.71) 17.03,44.74 17.51,44.74 18.18,44.06 v3(18.18,43.76) 18.18,43.33 v3(18.27,43.25) 18.45,43.07 v3(18.45,41.89) 18.25,41.89 17.86,41.51 17.86,40.42 v3(18.27,40.01) ; 52.69,22.59 53.36,21.92 55.79,21.92 55.92,22.05 ; v3(21.57,37.47) 20.91,38.13 20.91,38.72 21.17,38.97 v3(21.17,39.91) 21.17,42.87 21.42,43.13 v3(21.42,43.62) 21.42,44.26 18.5,47.17 v3(18.22,47.17) 18.17,47.17 17.97,47.38 17.97,48.93 15.82,51.07 v3(15.82,51.45) 15.49,51.45 13.78,53.17 12.33,53.17 10.96,54.54 ; v3(75.93,30.16) 75.2,30.88 75.2,32.75 74.94,33.01 74.94,42.15 74.33,42.75 73.32,43.77 73.32,43.87 v3(73.06,44.13) 73.06,44.43 v3(72.55,44.94) ; v3(75.93,30.16) 76.56,30.16 77.12,30.71 77.12,32.74 76.22,33.64 76.22,42.67 75.01,43.87 75.01,45.03 74.3,45.75 74.3,47.15 v3(73.8,47.66) 73.59,47.86 73.59,54.51 72.27,55.84 72.27,56.46 73,57.18 v3(73.29,57.18) 73.57,57.46 73.57,57.75 76.68,60.86 78.52,60.86 79.23,61.57 86.59,61.57 v3(86.62,61.54) v3(91.67,61.54) 94.85,61.54 v3(94.88,61.57) 95.44,62.13 112.05,62.13 v3(112.36,61.83) ; v3(62.06,23.53) 62.06,23.32 60.31,21.57 56.81,21.57 56.51,21.88 56.1,21.88 55.92,22.05 ; 128.89,62.44 130.31,62.44 v3(130.51,62.64) 130.72,62.44 139.25,62.44 139.96,61.73 139.96,61.02 139.25,60.31 138.34,60.31 v3(138.22,60.43) ; v3(72.55,44.94) 72.82,45.21 72.82,46.53 72.32,47.03 72.32,53.6 v3(71.33,54.59) 71.33,54.67 71,55 71,56.99 76.15,62.13 77.99,62.13 78.46,62.6 v3(78.46,63.01) 78.65,63.2 v3(88.68,63.2) v3(93.76,63.2) 94.04,63.48 115.55,63.48 118.5,60.54 v3(118.5,60.2) v3(118.5,58.97) v3(118.5,57.96) v3(118.5,57.19) 118.5,56.77 119.38,55.89 119.38,54.47 119.74,54.11 120.91,54.11 121.85,53.16 121.85,49.43 122.97,48.32 123.45,48.32 123.78,48.65 125.57,48.65 125.92,48.3 125.92,47.94 125.84,47.86 125.84,46.62 126.55,45.9 126.55,45.17 126.35,44.96 125.56,44.96 v3(124.81,45.71) 124.52,46.01 v3(124.19,46.01) 123.38,46.01 121.24,48.14 v3(121.01,48.14) 121.01,48.42 120.58,48.85 120.58,52.63 120.38,52.84 119.92,52.84 119.57,52.49 ; v3(84.51,16.97) 84.59,16.9 88.32,16.9 88.53,16.69 v6(89.04,16.69) ; v6(72.93,9.41) 72.93,9.42 73.84,10.33 75,10.33 v3(75.18,10.15) 75.32,10.29 85.58,10.29 v3(87.44,8.44) v3(88.58,7.3) 88.94,6.93 114.86,6.93 115.81,7.88 119.49,7.88 v6(119.67,8.06) 119.98,7.75 120.94,7.75 121.4,8.22 v3(123.05,8.22) v3(123.81,8.22) v3(124.7,8.22) v3(126.4,8.22) v3(127.24,8.22) v3(128,8.22) v3(128.89,8.22) v3(129.78,8.22) v3(130.54,8.22) 131.26,8.22 v3(131.28,8.24) 132.17,8.24 v3(132.19,8.22) v3(133.08,8.22) v3(133.84,8.22) v3(134.73,8.22) v3(135.49,8.22) v3(136.38,8.22) v3(137.14,8.22) v3(138.67,8.22) v3(139.43,8.22) 140.14,8.93 140.14,9.99 143.37,13.21 143.37,20.99 v3(142.93,21.42) 143.11,21.6 v3(143.11,27.95) 143.11,28.53 143.65,29.06 143.9,29.06 v3(144.14,29.3) 144.14,29.56 145.17,30.59 145.17,31.78 145.49,32.1 145.49,32.28 v3(145.96,32.75) 146.46,32.24 146.46,30.54 145.42,29.5 145.42,28.99 144.72,28.29 144.72,27.45 v3(144.76,27.41) 144.38,27.03 144.38,19.96 v3(145.25,19.1) 144.38,18.24 144.38,12.81 141.13,9.56 141.13,8.67 v3(141.59,8.22) 140.36,6.99 134.96,6.99 v3(134.78,6.81) 134.73,6.86 v3(126.88,6.86) 121.88,6.86 121.78,6.76 v3(121.72,6.76) 115.98,6.76 115.31,6.08 ; 15.94,29.4 15.96,29.42 ; 111.08,46.39 111.08,45.52 110.6,45.04 108.68,45.04 v3(108.54,44.9) ; v3(114.74,61.96) 114.49,62.21 112.74,62.21 v3(112.36,61.83) ; v3(114.74,61.96) 115.28,61.96 116.95,60.29 116.95,59.59 116.44,59.09 v3(115.88,59.09) ; v3(114.74,61.96) 114.56,61.78 114.56,61.22 114.21,60.87 114.21,59.9 115.02,59.09 v3(115.88,59.09) ; 64.98,6.76 64.7,6.48 64.22,6.48 63.58,5.85 61.91,5.85 v3(61.07,5.01) ; 112,45.9 111.74,45.65 111.74,45.25 110.87,44.38 109.21,44.38 108.38,43.55 v3(107.74,43.55) ; 119.57,52.49 118.11,53.94 118.11,55.37 116.44,57.03 116.44,57.92 115.88,58.48 v3(115.88,59.09) ; 17.25,20.68 17.56,20.38 18.47,20.38 v3(18.96,20.87) ; v3(50.63,23.63) 51.31,24.31 54.26,24.31 54.95,23.63 54.95,23.16 55.92,22.19 55.92,22.05 ; v3(50.63,23.63) 50.63,23.03 51.04,22.62 52.69,22.62 ; 43.06,28.35 43.06,27.43 ; 115.12,32.37 115.12,31.07 114.69,30.64 v3(113.14,30.64) 112.84,30.33 112.84,29.9 112.36,29.42 108.93,29.42 108.59,29.09 107.48,29.09 v3(107.17,29.39) 107.04,29.52 104.96,29.52 104.61,29.17 104.15,29.17 103.79,29.52 v3(103.79,29.72) 103.74,29.72 102.73,28.71 101.86,28.71 101.25,28.1 101.25,27.01 100.91,26.66 99.19,26.66 96.63,24.1 96.63,23.76 v3(96.76,23.63) 96.81,23.58 97.51,23.58 98.15,24.23 98.15,24.83 99.48,26.15 101.24,26.15 101.86,26.78 101.86,27.62 v3(102.09,27.84) 102.38,28.14 102.94,28.14 103.46,28.66 104.5,28.66 v3(104.71,28.45) 105.19,28.94 106.54,28.94 106.89,28.58 108.9,28.58 109.23,28.92 112.84,28.92 v3(113.75,29.83) 113.95,30.03 114.8,30.03 115.63,30.86 115.63,32.98 116.06,33.41 116.06,34.17 115.91,34.32 115.91,34.52 v3(115.88,34.55) 115.53,34.55 115.12,34.14 115.12,33.97 114.97,33.81 114.97,32.52 115.12,32.37 ; 101.89,35.8 101.89,37.57 103.14,38.83 104.64,38.83 104.74,38.72 105.6,38.72 v3(105.94,38.39) 105.94,38.07 105.62,37.76 105.05,37.76 104.91,37.9 104.91,38.08 104.75,38.24 103.57,38.24 102.62,37.29 102.62,35.51 102.04,34.93 100.85,34.93 100.73,34.81 100.73,33.17 101.23,32.68 101.23,30.97 101.33,30.87 v3(101.76,30.87) 101.86,30.87 102.27,30.46 102.27,30 102.04,29.77 101.05,29.77 100.47,30.36 100.47,32.19 100.07,32.58 100.07,35.09 100.68,35.7 101.79,35.7 101.89,35.8 ; 142.45,37.47 144.8,37.47 146.63,35.64 148.19,35.64 149.13,34.7 149.13,33.36 147.86,32.09 147.86,31.81 148.27,31.4 148.9,31.4 149.72,32.21 v3(149.72,32.39) 149.84,32.52 149.84,35.11 148.51,36.44 v3(148.31,36.44) 148,36.44 147.84,36.28 146.86,36.28 145.06,38.08 143.16,38.08 v3(142.07,39.17) 141.38,39.86 134.1,39.86 133.46,40.5 v3(133.46,40.77) 133.18,40.77 132.44,41.51 v3(132.44,41.74) 132.24,41.74 130.62,43.36 130.34,43.36 128.48,45.22 128.48,52.28 v3(128.35,52.41) 128.35,52.61 127.95,53.02 127.29,53.02 127.03,52.76 127.03,52.23 v3(127.55,51.71) 127.55,51.17 v3(127.64,51.09) 127.64,50.83 127.87,50.6 127.87,44.96 130.08,42.75 130.28,42.75 133.79,39.25 135.87,39.25 136.1,39.02 v3(136.51,39.02) 140.9,39.02 v3(141.97,37.95) 142.45,37.47
  IN4 w0.058: v4(102.87,49.37) v3(102.5,49.37) ; v3(54.64,12.63) 54.31,12.96 53.32,12.96 52.81,12.45 52.05,12.45 51.8,12.71 51.8,13.26 52.56,14.03 53.17,14.03 53.5,14.36 54.18,14.36 v3(54.71,14.89) ; v3(54.64,12.63) 55.18,12.1 v4(55.63,12.1) 55.89,12.1 56.83,13.04 v3(56.83,13.29) v4(56.83,13.77) 56.83,13.95 56.68,14.1 56.68,15.73 56.4,16.01 v5(56.37,16.01) 55.3,16.01 54.69,15.4 54.69,14.91 v3(54.71,14.89) ; v3(54.64,12.63) 54.64,13.39 v4(54.85,13.6) 54.85,14.76 v3(54.71,14.89) ; v5(37.8,22.51) 37.8,22.64 37.45,22.99 v3(35.92,22.99) 35.51,22.58 35.51,20.79 v5(35.8,20.5) v5(35.8,18.55) v4(35.8,16.77) 36.1,16.47 36.13,16.47 37.28,15.31 39.36,15.31 39.8,15.75 39.99,15.75 v5(40.78,16.54) 41,16.77 v5(41,18.42) v5(41,20.58) 41,21.34 40.6,21.75 v5(40.54,21.75) ; v5(108.85,37.66) 108.45,37.66 v3(108.44,37.66) ; 104.22,39.77 103.54,39.77 101.27,37.5 v3(101.24,37.5) 100.73,37.5 100.65,37.43 v5(98.18,37.43) 97.95,37.43 97.65,37.73 97.65,37.75 95.31,40.09 92.05,40.09 v3(92.01,40.04) 91.79,40.04 v3(90.38,38.64) ; v5(106.94,26.88) 106.87,26.8 106.33,26.8 v3(105.57,27.57) 105.14,27.57 104.71,28 v3(104.71,28.45) 104.25,28.91 v5(104,28.91) 103.69,28.91 103.39,28.61 103.39,28.1 103.59,27.84 103.54,27.54 103.54,27.23 103.72,27.06 104.63,27.06 104.85,26.84 v5(104.85,26.32) 105.37,26.32 105.62,26.07 110.48,26.07 v3(110.7,25.84) 111.19,25.36 112.23,25.36 112.94,26.07 112.94,26.57 112.53,26.98 v3(110.5,26.98) 110.4,26.88 109.28,26.88 109.18,26.98 v5(108.67,26.98) ; v5(108.67,26.98) 108.49,26.8 107.96,26.8 107.76,27.01 107.76,28.81 v5(107.45,29.11) v3(107.17,29.39) 107.17,29.65 107.81,30.29 v5(109.15,30.29) 109.28,30.16 109.28,27.9 108.67,27.29 v5(108.67,26.98) ; v3(88.53,58.1) 88.74,58.32 91.91,58.32 92.08,58.15 v3(92.08,58.08) ; v3(39.71,23.12) 39.48,23.35 v3(38.54,23.35) ; v3(97.36,47.12) 97.36,46.97 96.33,45.94 96.33,45.43 95.18,44.29 v3(95.18,44.08) ; v5(86.94,36.37) 86.82,36.49 v3(86.55,36.49)
  IN4 w0.075: 106.41,41.06 106.48,41.14 106.48,42.38 ; 91.37,40.4 90.61,39.64 ; 104.58,40.65 104.82,40.65 v3(105.62,41.45) ; 104.58,40.65 104.22,40.28 104.22,39.77 104.48,39.51 105.44,39.51 105.72,39.79 105.72,40.3 ; 104.58,40.65 104.58,42.1 v4(104.58,42.1) 104.91,42.43 105.52,42.43 105.55,42.4 v5(105.82,42.4) 104.98,43.24 104.98,46.78 103.84,47.92 103.23,47.92 103.16,47.99 ; v3(90.38,38.64) 90.38,38.35 90.1,38.07 90.1,36.69 89.33,35.92 88.73,35.92 v5(88.64,35.83) 88.53,35.94 87.72,35.94 87.21,36.46 87.04,36.46 86.95,36.36 v5(86.94,36.37)
  IN4 w0.076: 92.41,40.8 92.62,41.01 93.73,41.01 v3(93.94,40.8) ; 92.41,40.8 91.77,40.8 91.37,40.4 ; 92.41,40.8 92.62,40.6 93.73,40.6 v3(93.94,40.8) ; v3(95.74,54.42) 95.79,54.42 97.15,53.06 97.15,49.41 98.36,48.2 102.95,48.2 103.16,47.99 ; 105.72,40.3 105.72,40.37 106.41,41.06 ; 106.48,42.38 106.48,43.06 v3(106.18,43.36) 105.45,44.09 105.45,47.03 104.01,48.48 103.82,48.48 v3(103.64,48.65) 103.59,48.7 98.84,48.7 98.71,48.83 98.71,48.89 v3(98.54,49.06) 98.46,48.98 98.33,48.98 97.6,49.71 97.6,53.56 95.99,55.17 95.99,55.52 v3(95.79,55.72) v3(92.87,58.64) 92.44,59.07 81.48,59.07 80.64,58.23 v5(80.45,58.23) 80.45,57.97 78.83,56.35 78.41,56.35 77.3,55.24 v3(77.3,54.45) 77.09,54.24 v4(77.09,52.33) 77.09,48.24 77.53,47.81 78.34,47.81 78.55,48.01 78.55,48.27 77.73,49.08 77.73,51.84 78.17,52.29 v3(78.32,52.29) 78.01,52.6 78.01,53.66 v5(78.35,54) 78.06,54.29 78.06,54.88 78.63,55.45 v3(78.63,55.5) 78.75,55.5 81.86,58.61 82.58,58.61 v5(83.07,58.13) 83.07,58.28 83.4,58.61 84.12,58.61 84.46,58.27 v5(84.46,58.13) 84.64,58.31 88.32,58.31 v3(88.53,58.1) ; v3(97.36,47.12) 97.6,47.36 101.58,47.36 101.9,47.03 101.9,43.58 101.18,42.86 101.18,42.43 101.56,42.04 102.34,42.04 102.6,42.31 102.6,42.63 102.37,42.86 102.37,47.21 101.61,47.97 98.26,47.97 98.06,48.17 97.01,48.17 96.5,47.66 96.5,46.8 95.84,46.14 95.84,45.63 95.09,44.88 94.38,44.88 93.85,44.35 93.85,42.28 v3(93.58,42.02) 93.58,41.75 93.3,41.47 91.71,41.47 90.54,40.3 90.15,40.3 89.47,40.98 89.16,40.98 89.01,40.82 89.01,40.23 ; v3(93.94,40.8) 94.14,40.6 95.54,40.6 97.85,38.29 101.37,38.29 103.31,40.23 103.31,42.2 103.51,42.4 104.28,42.4 v4(104.58,42.1) ; v3(93.94,40.8) 94.02,40.88 94.02,41.22 94.31,41.51 94.31,44.09 94.55,44.33 94.93,44.33 v3(95.18,44.08) ; v3(105.62,41.45) 105.82,41.64 v5(105.82,42.4)
  IN4 w0.152: v5(37.8,22.51) 38.2,22.91 38.2,23.01 v3(38.54,23.35) ; v5(40.54,21.75) 40.54,22.06 40.39,22.21 40.39,22.46 39.99,22.87 39.86,22.87 39.71,23.02 v3(39.71,23.12)
  IN4 w0.2: v3(84.44,48.63) 84.62,48.63 v4(84.78,48.78)
  IN4 w0.203: v5(44.94,4.43) 44.84,4.53 44.84,4.55 v3(44.69,4.71) ; v3(42.07,4.73) 41.92,4.58 v5(41.72,4.58) ; v5(30.06,38.08) 30.06,38.56 v3(30.08,38.59) ; v5(41.05,36.3) v3(41.05,35.97) ; v5(86.26,33.85) 86.62,34.2 v3(86.62,34.37) 86.42,34.57 v5(86.26,34.57) ; v5(111.51,42.37) 111.58,42.3 v3(111.84,42.3) ; v5(112.51,41.47) 112.51,41.39 112.71,41.19 v3(112.73,41.19) ; v3(26.5,38.52) v5(26.88,38.52) ; v3(109.86,37.9) 109.62,37.66 v5(109.3,37.66) ; v3(128.09,58.83) 128.03,58.76 v5(127.67,58.76) ; v3(36.56,36.63) 36.41,36.63 36.05,36.28 v5(36.05,36.25) ; v3(107.89,59.2) 107.9,59.19 v5(107.9,58.76) ; v5(47.79,5.09) 47.79,5.29 47.61,5.47 47.61,5.7 47.49,5.82 v3(47.49,5.92) ; v5(39.55,36.25) v3(39.23,36.57) ; v5(105.86,59.7) 105.88,59.72 v3(106.35,59.72) ; v5(104.3,36.72) 104.22,36.79 104.05,36.79 v3(103.97,36.87) ; v5(111.36,38.32) 111.54,38.32 v3(111.67,38.19) ; v5(46.5,9.05) v3(46.5,9.44) ; v5(28.41,38.97) v3(28.85,39.41) ; v5(111.44,43.07) 111.46,43.09 v3(111.81,43.09) ; v5(107.81,37.98) 107.7,37.88 107.7,37.7 v3(107.68,37.68)
  IN4 w0.254: v3(37.73,16.41) 38.03,16.11 v5(38.11,16.11) ; v3(105.67,28.48) v5(105.67,28.1) ; v5(103.27,55.9) v3(102.92,55.55) 102.87,55.55 v5(102.51,55.9) ; v3(134.07,47.07) 133.92,47.22 v5(133.92,47.91) ; v5(141.28,28.26) 141.06,28.48 v3(140.67,28.48) ; v3(104.39,58.86) 104.36,58.83 104.36,58.58 v5(104.31,58.53) ; v3(144.23,33.46) 143.96,33.73 v4(143.96,33.95) ; v5(53.05,6.2) v3(53.05,5.82) ; v3(146.13,47.68) 146.13,47.76 146.63,48.26 v5(146.89,48.26) ; v3(134.52,60.02) 134.85,59.7 v5(134.92,59.7) ; v3(145.82,59.52) v5(145.4,59.52) ; v3(145.02,32.32) v5(144.72,32.45) ; v5(34.55,36.25) 34.4,36.4 v3(34.4,36.94) ; v5(136.82,40.04) 136.82,39.33 v3(136.51,39.02) ; v5(141.11,43.64) 141.16,43.64 v3(141.46,43.95) ; v3(133.33,55.56) v5(133.66,55.23) ; v5(130.3,63.3) 130.3,62.86 v3(130.51,62.64) 130.41,62.54 v5(130.41,62.24) ; v3(39.12,16.24) 39,16.11 v5(38.79,16.11) ; v3(102.78,57.71) 102.59,57.71 102.31,57.99 v5(102.31,58.18) ; v3(142.06,59.76) v5(142.39,59.76) ; v5(28.02,15.63) 28.02,14.97 v3(27.92,14.87)
  IN5 w0.076: 82.2,32.45 82.38,32.45 82.61,32.68 82.61,33.37 ; 82.2,32.45 82.05,32.6 82.05,33.37 ; 82.2,32.45 81.95,32.2 81.95,30.99 82.3,30.63 83.35,30.63 84.51,29.48 101.83,29.48 104.4,32.05 v4(104.4,32.47) ; v5(107.09,43.03) 107.09,43.39 v5(107.45,43.74) 107.5,43.8 v5(107.5,44.97) v5(107.5,45.91) v5(107.5,46.7) 107.5,48.27 110.36,51.12 114.71,51.12 115.98,49.84 115.98,48.93 116.09,48.82 116.09,47.4 115.88,47.2 114.87,47.2 114.46,47.61 114.46,49.23 114.16,49.54 110.9,49.54 109.08,47.71 v4(109.08,47.35) v4(109.08,44.66) ; v5(107.09,43.03) 106.45,43.03 v5(105.82,42.4) 105.42,42 105.42,41.41 103.89,39.88 v5(103.89,39.59) ; v5(107.09,43.03) 107.09,42.93 107.25,42.78 107.25,42.53 105.6,40.87 105.6,39.28 105.98,38.89 105.98,37.73 v4(106.07,37.64) ; v5(103.84,38.64) 103.84,39.54 v5(103.89,39.59) ; v5(103.84,38.64) 103.92,38.64 104.32,38.24 104.95,38.24 105.06,38.13 105.06,37.19 104.91,37.04 104.88,37.04 ; v5(103.84,38.64) 103.84,37.89 ; 104.5,37.04 104.88,37.04 ; 104.5,37.04 104.5,37.12 104.66,37.27 104.66,37.55 104.31,37.9 103.85,37.9 103.84,37.89 ; 104.5,37.04 104.3,36.84 v5(104.3,36.72) 104.3,35.24 v4(104.4,35.14) 104.25,34.99 104.25,32.63 v4(104.4,32.47) ; 104.88,37.04 105.04,36.88 105.04,34.67 v5(104.88,34.51) 105.04,34.35 105.04,32.63 104.89,32.48 104.4,32.48 v4(104.4,32.47) ; 103.84,37.89 103.49,37.53 v5(103.49,37.27) 103.49,35.42 v4(103.58,35.33) 103.77,35.14 103.77,32.19 101.53,29.95 84.7,29.95 83.9,30.75 83.9,31.1 82.54,31.1 82.43,31.22 82.43,31.83 83.09,32.49 83.09,33.77 ; v5(103.89,39.59) 104.1,39.59 104.43,39.25 104.87,39.25 105.52,38.6 105.52,35.45 v4(105.7,35.27) 105.52,35.09 105.52,31.69 v4(105.42,31.59) 104.65,31.59 102.06,28.99 84.32,28.99 83.14,30.18 82.11,30.18 81.44,30.85 81.44,32.82 81.36,32.9 ; 82.86,34.68 83.19,34.68 83.35,34.53 ; v4(107.04,37.05) 107.04,37.75 107.15,37.85 107.15,38.87 107.48,39.2 107.48,39.41 107.27,39.61 v4(107.27,39.69) 107.27,40.06 107.27,40.06 v5(107.27,40.19) 107.35,40.27 107.35,40.65 108.67,41.97 v4(108.67,42.73) ; 108.85,33.41 v5(108.85,33.31) 107.98,33.31 106.92,32.24 106.92,30.38 v4(106.97,30.33) 106.92,30.28 106.92,28.17 106.05,27.31 105.65,27.31 104.85,26.51 v5(104.85,26.32) 102.56,24.03 95.87,24.03 v4(95.77,23.93) 95.66,24.03 79.61,24.03 v4(79.51,23.93) 79.38,24.06 70.47,24.06 v4(70.34,23.93) 70.21,24.06 63.58,24.06 61.32,21.8 61.02,21.8 60.49,21.27 58.25,21.27 58.14,21.15 57.02,21.15 v4(56.85,20.99) 56.69,21.15 54.78,21.15 v5(54.31,20.68) 54.18,20.55 53.69,20.55 53.49,20.75 53.49,21.18 v5(53.7,21.39) 54.16,21.85 57.77,21.85 57.92,22 60.21,22 60.94,22.74 v5(61.07,22.74) 61.25,22.74 63.28,24.77 63.89,24.77 v4(63.97,24.85) 64.04,24.77 70.21,24.77 v4(70.39,24.95) v4(80.55,24.95) 80.73,24.77 102.09,24.77 105.42,28.1 v5(105.67,28.1) 106.13,28.56 106.13,29.27 v5(106.08,29.32) v4(106.08,30.44) 106.08,32.42 107.86,34.19 108.47,34.19 108.67,33.99 108.67,33.58 108.85,33.41
  IN5 w0.254: v5(109.15,30.62) v5(109.15,30.29)
  BOTTOM w0.076: SH2140.2 110.52,40.88 110.49,40.91
  BOTTOM w0.089: v5(148.11,32.45) v5(144.72,32.45) 143.96,31.69 v5(143.96,30.95) v5(148.1,30.95) ; v5(111.49,35.52) 111.52,35.55 111.66,35.55 111.82,35.7 SH2144.2 ; v5(50.57,18.57) 50.56,18.57 U6548.5 ; v5(118.83,62.54) 118.63,62.54 117,60.92 112.94,60.92 v5(112.63,60.61) 112.23,61.02 v5(112.23,62.24) 112.43,62.44 116.29,62.44 116.5,62.65 J20.1 ; v5(7.73,57.33) 8.19,57.33 9.08,56.44 9.08,55.81 9.46,55.43 9.46,55.1 10.02,54.54 10.86,54.54 12.36,53.04 v5(12.36,52.91) ; v5(43.8,2.77) 47.6,2.77 47.79,2.96 CON16.1 48.53,3.6 49.26,4.32 49.26,4.71 49.89,5.34 50.4,5.34 50.66,5.09 50.66,4.45 48.37,2.17 43.29,2.17 43.04,2.42 43.04,2.65 v5(42.91,2.77) ; v5(42.91,7.25) 43.18,6.97 48.78,6.97 49.7,7.89 50.83,7.89 51.23,7.5 51.67,7.5 51.8,7.63 51.8,8.26 51.67,8.39 v5(51.42,8.39) 49.51,8.39 48.58,7.46 44.23,7.46 44.1,7.59 CON16.20 ; v5(110.32,41.08) 110.49,40.91 ; v5(7.55,55.84) 7.55,55.71 7.98,55.28 7.98,54.16 9,53.15 9.25,53.15 v5(9.5,52.9) 9.5,52.73 R90810.2 10.3,51.67 10.04,51.42 10.04,50.78 10.78,50.04 14.64,50.04 18.98,45.69 v5(18.98,45.29) 20.86,43.41 v5(23,43.41) 23,43.29 23.33,42.96 24.19,42.96 24.47,43.24 24.47,43.62 v5(24.37,43.72) 23.67,44.42 v5(21.31,44.42) v5(19.77,45.95) 19.4,46.32 19.11,46.32 14.68,50.76 12.33,50.76 12.02,51.06 12.02,51.67 v5(11.77,51.92) ; v5(108.85,33.31) 109,33.46 SH6101.1 ; v5(88.22,11.18) 87.69,11.72 v5(82.38,11.72) 80.22,11.72 v5(77.81,9.3) 73.81,5.31 v5(71,5.31) 64.73,5.31 63.97,6.08 v5(63.97,6.33) 63.97,6.51 64.24,6.79 65.11,6.79 65.77,6.13 v5(66.23,6.13) v5(71.23,6.13) 73.47,6.13 v5(77.43,10.09) 80.04,12.71 v5(82.25,12.71) 82.46,12.5 87.59,12.5 88.25,13.16 v5(88.43,13.16) ; 31,28.61 v5(30.72,28.33) 30.69,28.35 30.11,28.35 29.85,28.1 29.85,26.75 30,26.6 v5(30.21,26.6) 30.21,26.3 30.74,25.76 30.74,25.36 30.59,25.2 28.43,25.2 v6(28.33,25.3) 28.91,25.89 28.91,26.37 29.14,26.6 29.14,28 v5(29.07,28.07) 29.07,28.33 30.06,29.32 35.95,29.32 v5(36.05,29.22) 36.33,29.22 36.68,28.87 36.68,27.04 38.87,24.85 39.58,24.85 41.77,22.66 47.86,22.66 48.09,22.43 v5(48.73,22.43) 49.92,22.43 v5(50.66,21.7) 51.88,21.7 52.18,21.39 v5(53.7,21.39) 53.82,21.39 54.31,20.9 v5(54.31,20.68) 54.11,20.48 52.08,20.48 51.77,20.78 v5(50.76,20.78) 50.45,20.78 49.64,21.6 47.71,21.6 v5(47.51,21.8) 47.35,21.95 42.17,21.95 v5(41.92,21.7) 41.72,21.7 39.33,24.09 38.62,24.09 35.97,26.73 35.97,28.15 35.8,28.33 v5(33.89,28.33) 33.61,28.61 31,28.61 ; 102.65,26.96 102.47,27.13 102.47,28.66 102.65,28.84 103.92,28.84 v5(104,28.91) 104.4,29.32 v5(106.08,29.32) 106.59,28.81 107.15,28.81 v5(107.45,29.11) 107.76,28.81 108.36,28.81 108.67,28.5 v5(108.67,26.98) 108.47,26.78 107.04,26.78 v5(106.94,26.88) 106.43,26.37 106.43,26.17 106.15,25.89 105.28,25.89 v5(104.85,26.32) 104.44,25.91 102.83,25.91 102.65,26.09 102.65,26.96 ; 39.33,37.12 39.55,36.89 v5(39.55,36.25) J15.12 39.55,34.34 38.97,33.76 37.98,33.76 37.7,34.04 37.7,34.96 38.05,35.31 J15.9 v5(38.05,36.25) 38.05,36.96 38.21,37.12 39.33,37.12
  BOTTOM w0.203: v5(39.7,9.42) CON16.42 ; C1830.2 87.03,39.22 v5(87.07,39.26) ; v5(90.83,35.15) 91.04,34.93 C6702.2 ; v5(47.79,5.09) CON16.1 ; v5(112.51,41.47) R2204.1 ; v5(44.94,4.43) 44.9,4.38 CON16.15 ; v5(64.63,44.2) C10683.1 ; C10372.2 54.87,19.4 54.29,19.98 v5(54.29,20) ; v5(81.31,37.33) 81.34,37.35 C1839.2 ; v5(87.03,39.94) 87.03,39.94 C1831.2 ; CON16.20 44.1,9.36 v5(44.08,9.38) ; v5(88.76,37.73) 88.43,37.73 88.32,37.83 v5(88.04,37.83) v5(87.33,37.83) ; v5(54.72,16.23) 54.82,16.33 C10367.2 ; v5(65.36,44.18) C10684.2 ; v5(41.72,4.58) 41.7,4.56 CON16.31 ; v5(40.93,9.81) 40.9,9.79 CON16.36 ; C1011.1 86.27,34.58 v5(86.26,34.57) ; C10674.1 63.53,42.04 62.36,43.21 v5(62.24,43.21) ; v5(103.49,37.27) 103.52,37.3 104.05,37.3 104.28,37.53 C2133.2 ; C10628.2 v5(107.27,40.19) ; C8201.2 108.84,38.27 109.3,37.81 v5(109.3,37.66) ; v5(46.5,9.05) CON16.8 ; C10677.1 66.25,42.62 v5(66.57,42.95) ; 87.65,36.37 v5(86.94,36.37)
  BOTTOM w0.254: U6581.2 71.41,40.98 v5(71.48,40.9) ; v5(105.67,28.1) 105.67,27.65 105.82,27.49 C6221.2 ; J17.8 v5(149.51,33.95) ; J20.1 116.5,63.97 116.8,64.27 v5(117.2,64.27) ; Q803.1 44.2,19.22 44.2,19.06 v6(44.61,18.65) ; J15.40 v5(53.55,37.22) ; U6538.7 130.33,62.15 v5(130.41,62.24) ; J17.14 v5(148.1,30.95) ; U1007.71 146.89,60.18 146.65,60.43 v5(146.6,60.43) ; J17.10 148.17,32.95 v5(148.09,32.87) ; U6581.4 v5(70.46,43.96) ; v5(94.01,35.19) 93.86,35.34 C4302.2 ; J17.18 v5(148.09,28.95) ; Q802.1 44.21,16.65 44.64,17.07 v6(44.64,17.33) ; J17.15 v5(148.11,30.45) ; Q798.1 64.43,23.07 64.65,23.3 v5(64.91,23.3) ; v5(42.63,35.11) 42.63,35.26 42.55,35.34 J15.18 ; C2132.2 101.86,27.62 v5(101.98,27.5) ; J17.11 v5(148.11,32.45) ; J17.17 v5(148.09,29.45)
  BOTTOM w0.381: U6539.3 122.42,60.78 122.31,60.89 v6(121.14,60.89)
  BOTTOM w0.508: CON9105.31 145.98,14.85 v6(146.61,15.48) ; C141.2 98.54,12.44 v6(98.2,12.1) ; C10712.2 C10713.2 115.96,27.57 v6(116.46,27.57) 116.57,27.57 116.81,27.81 C10496.2 ; CON9104.5 30.42,5.17 v6(30.17,5.42) ; C10662.2 100.14,20.17 v6(100.14,20.06) ; C10493.2 v6(138.58,35.06)
  vias: v1(13.64,15.3) v1(13.64,14.92) v1(13.64,14.54) v1(15.34,15.97) v1(15.38,11.41) v1(15.71,15.98) v1(15.95,28.11) v1(15.93,13.44) v1(16.32,29.95) v1(17,36.18) v1(17.23,36) v1(17.84,15.6) v1(17.84,14.79) v1(18.45,15.6) v1(18.45,14.79) v1(19.46,17.84) v1(19.46,17.02) v1(19.67,12.35) v1(20.07,17.84) v1(20.07,17.02) v1(20.58,20.07) v1(20.58,19.77) v1(21.09,3.03) v1(21.5,3.03) v1(22.51,5.44) v1(22.51,2.98) v1(23.25,33.41) v1(23.5,0.86) v1(24.03,28.12) v1(24.34,30.38) v1(24.37,32.14) v1(38.56,18.33) v1(39.96,22.24) v1(39.96,16.39) v1(41.26,10.96) v1(41.89,28.53) v1(42.73,10.55) v1(43.16,12.93) v1(43.64,26.55) v1(46.85,11.34) v1(49.39,26.96) v1(49.41,10.14) v1(51.27,30.25) v1(51.65,37.3) v1(52.56,36.68) v1(53.83,21.47) v1(54.48,15.9) v1(54.98,17.91) v1(54.98,17.41) v1(54.98,16.9) v1(55.48,17.91) v1(55.48,17.41) v1(55.48,16.9) v1(55.98,17.91) v1(55.98,17.41) v1(55.98,16.9) v1(57.76,21.47) v1(60.39,21.29) v1(60.71,13.6) v1(61.35,15.6) v1(61.73,20.26) v1(61.74,6.7) v1(62.22,8.01) v1(62.59,37.98) v1(62.59,37.47) v1(62.84,12.84) v1(63.36,37.98) v1(63.36,37.47) v1(64.5,32.8) v1(64.63,36.46) v1(64.63,35.82) v1(64.73,32.62) v1(64.83,39.14) v1(65.39,36.46) v1(65.39,35.82) v1(65.69,23.68) v1(66.02,22.82) v1(66.02,22.56) v1(66.68,22.82) v1(66.68,22.56) v1(67.88,21.27) v1(67.88,21.01) v1(68.54,21.27) v1(68.54,21.01) v1(70.26,7.45) v1(70.7,7.45) v1(71.15,7.45) v1(72.11,37.02) v1(72.12,36.73) v1(72.37,29.7) v1(72.37,27.87) v1(74.74,25.69) v1(74.71,24.67) v1(74.74,23.7) v1(74.79,50.35) v1(74.84,49.23) v1(74.81,48.39) v1(74.79,47.55) v1(74.81,46.41) v1(74.81,45.32) v1(74.76,42.04) v1(74.79,40.67) v1(74.79,39.63) v1(74.79,38.97) v1(74.81,37.95) v1(74.81,37.04) v1(74.79,36.2) v1(74.81,34.91) v1(74.81,33.33) v1(74.86,50.98) v1(75.04,64.4) v1(74.96,63.73) v1(75.01,62.87) v1(74.99,62.13) v1(75.01,61.04) v1(74.96,60.05) v1(75.17,59.01) v1(75.17,55.56) v1(75.19,54.92) v1(75.34,53.57) v1(75.34,52.28) v1(75.4,58.12) v1(75.37,57.38) v1(75.37,56.52) v1(75.78,23.12) v1(75.88,66.55) v1(76.94,23.07) v1(76.97,66.55) v1(78.19,23.04) v1(78.34,66.55) v1(79.61,66.55) v1(79.89,54.22) v1(80.2,22.82) v1(80.3,43.8) v1(80.3,43.4) v1(80.83,66.55) v1(81.14,57.06) v1(81.41,29.91) v1(81.41,29.65) v1(81.41,29.4) v1(81.41,29.15) v1(81.41,28.89) v1(81.39,28.64) v1(81.39,28.38) v1(81.59,22.82) v1(81.87,66.55) v1(82,57.06) v1(82.33,30.03) v1(82.33,29.75) v1(82.33,29.5) v1(82.33,29.24) v1(82.36,28.99) v1(82.79,57.06) v1(82.86,30.06) v1(82.86,29.76) v1(82.91,22.79) v1(82.99,66.5) v1(83.17,59.45) v1(83.16,30.06) v1(83.16,29.76) v1(83.43,37.16) v1(83.41,33.56) v1(83.42,30.06) v1(83.42,29.73) v1(83.72,52.26) v1(83.83,33.99) v1(83.96,66.53) v1(84.33,59.58) v1(84.26,28.77) v1(84.31,22.82) v1(84.51,56.96) v1(84.64,59.37) v1(84.64,58.89) v1(84.55,53.89) v1(84.62,30.92) v1(85,66.53) v1(85.2,22.92) v1(85.43,39.96) v1(85.43,31.53) v1(85.86,66.55) v1(85.88,29.73) v1(85.89,28.81) v1(85.89,28.07) v1(86.54,30.44) v1(86.57,29.58) v1(86.67,59.47) v1(86.69,58.74) v1(86.73,57.04) v1(86.85,58.97) v1(86.93,58.02) v1(87.05,31.07) v1(87.08,22.76) v1(87.18,59.47) v1(87.2,52.69) v1(87.26,66.53) v1(87.61,59.5) v1(87.71,58.02) v1(87.71,57.04) v1(88.07,59.5) v1(88.23,23.36) v1(88.5,62.34) v1(88.65,66.5) v1(88.68,57.11) v1(88.91,60.2) v1(89.39,51.82) v1(89.64,57.97) v1(89.92,57.04) v1(90.05,66.58) v1(90.05,45.1) v1(90.13,23.27) v1(90.18,58.73) v1(90.2,51.82) v1(90.53,62.34) v1(90.84,60.31) v1(91.07,57.33) v1(91.09,23.3) v1(91.32,51.85) v1(91.63,66.58) v1(91.88,58.88) v1(92.16,62.34) v1(92.36,57.13) v1(92.36,51.85) v1(92.92,66.55) v1(92.97,50.96) v1(93.23,60.43) v1(93.25,52.97) v1(93.58,57.33) v1(93.58,31.2) v1(93.63,30.94) v1(93.84,31.43) v1(93.84,30.75) v1(93.86,59.54) v1(93.91,47.31) v1(94.01,62.36) v1(94.04,55.77) v1(94.04,55.51) v1(93.96,51.85) v1(94.01,49.12) v1(94.01,48.87) v1(94.09,55.26) v1(94.12,53.96) v1(94.09,31.4) v1(94.19,46.18) v1(94.27,66.58) v1(94.29,55.51) v1(94.34,55.26) v1(94.27,43.87) v1(94.34,31.4) v1(94.34,30.72) v1(94.6,52.94) v1(94.65,49.11) v1(94.65,48.86) v1(94.6,31.4) v1(94.6,30.71) v1(94.6,28.38) v1(94.6,28.12) v1(94.78,58.65) v1(94.93,56.09) v1(94.85,46.21) v1(94.85,28.4) v1(94.85,28.12) v1(94.9,23.27) v1(95.06,54.9) v1(95.11,28.41) v1(95.11,28.13) v1(95.08,27.87) v1(95.18,43.49) v1(95.36,51.85) v1(95.36,28.4) v1(95.36,28.15) v1(95.46,57.38) v1(95.77,59.75) v1(95.86,45.3) v1(96.05,66.58) v1(96.15,47.94) v1(96.15,44.46) v1(96.43,44.2) v1(96.43,23.22) v1(96.48,47.3) v1(96.55,55) v1(96.66,62.26) v1(96.71,58.45) v1(96.73,49.74) v1(96.71,44.46) v1(96.68,27.77) v1(97.01,56.01) v1(97.14,51.75) v1(97.11,23.02) v1(97.21,48.6) v1(97.32,27.13) v1(97.42,54.06) v1(97.44,46.41) v1(97.42,45.4) v1(97.47,66.58) v1(97.57,50.78) v1(97.82,59.62) v1(97.85,47.94) v1(97.9,57.51) v1(98,26.14) v1(98.15,61.37) v1(98.18,55) v1(98.23,51.72) v1(98.28,49.76) v1(98.48,56.04) v1(98.69,58.45) v1(98.74,47.94) v1(98.81,26.14) v1(98.89,66.55) v1(98.89,53.96) v1(98.89,50.76) v1(98.94,49.64) v1(98.99,62.26) v1(99.04,57.54) v1(99.02,48.72) v1(98.98,33.15) v1(99.09,32.92) v1(99.23,33.18) v1(99.35,55) v1(99.37,33.56) v1(99.63,60.51) v1(99.6,59.75) v1(99.55,32.96) v1(99.65,51.72) v1(100.06,66.55) v1(100.06,56.09) v1(100.08,52.97) v1(100.31,61.32) v1(100.49,54.03) v1(100.67,62.19) v1(101.2,52.1) v1(101.25,66.53) v1(101.33,55.73) v1(101.25,54.95) v1(101.74,54.03) v1(102.14,52.99) v1(102.27,55.68) v1(102.27,54.95) v1(102.53,14.73) v1(102.65,51.8) v1(102.68,66.58) v1(102.88,23.35) v1(103.13,53.96) v1(103.46,55.61) v1(103.54,52.13) v1(103.46,29.85) v1(103.74,66.55) v1(103.74,23.32) v1(103.86,32.85) v1(103.86,32.55) v1(104.05,52.97) v1(104.12,54.84) v1(104.14,32.83) v1(104.12,32.55) v1(105.01,55.61) v1(105.01,53.98) v1(105.11,66.55) v1(105.77,52.97) v1(105.93,54.84) v1(106.43,66.53) v1(106.66,55.71) v1(106.69,53.98) v1(107.39,58.36) v1(107.53,52.99) v1(107.6,54.84) v1(107.89,58.86) v1(107.89,57.86) v1(107.98,66.5) v1(109.41,66.48) v1(109.49,32.75) v1(109.48,31.26) v1(109.68,31.92) v1(109.68,31.66) v1(109.68,31.41) v1(110.52,66.48) v1(110.83,50.41) v1(110.85,41.1) v1(110.98,30.61) v1(110.98,29.98) v1(111.18,50.48) v1(111.42,30.3) v1(111.57,38.94) v1(111.74,35.64) v1(111.79,40.19) v1(111.87,29.98) v1(112.02,66.5) v1(112.12,43.47) v1(112.12,43.21) v1(112.12,42.96) v1(112.35,43.35) v1(112.35,43.08) v1(112.35,42.83) v1(113.19,60.49) v1(113.34,57.32) v1(113.39,66.48) v1(113.8,23.27) v1(114.26,59.49) v1(114.54,22.99) v1(114.79,66.45) v1(115.42,34.76) v1(115.83,39.15) v1(115.83,38.72) v1(116.04,38.92) v1(116.06,37.6) v1(116.16,66.5) v1(116.18,39.16) v1(116.18,38.7) v1(117.51,66.48) v1(117.53,25.99) v1(117.51,24.03) v1(117.51,23.42) v1(117.51,22.71) v1(117.56,24.95) v1(117.73,62.8) v1(117.81,65.26) v1(117.84,63.94) v1(117.81,61.8) v1(117.79,46.16) v1(117.81,44.99) v1(117.84,43.97) v1(117.84,27.36) v1(117.86,59.98) v1(117.86,35.24) v1(117.86,34.91) v1(117.86,33.46) v1(117.89,32.31) v1(117.86,30.33) v1(117.86,29.5) v1(123.3,10.14) v1(124.01,10.14) v1(124.72,10.14) v1(124.84,49.92) v1(124.9,37.52) v1(125.34,49.92) v1(125.28,37.52) v1(125.43,10.14) v1(125.84,49.92) v1(126.86,10.14) v1(127.67,10.14) v1(128.48,10.14) v1(128.76,20.55) v1(129.29,10.14) v1(129.62,50.04) v1(129.6,36.02) v1(129.6,35.72) v1(129.9,36.02) v1(129.9,35.72) v1(130.01,10.14) v1(130.41,20.55) v1(130.72,10.14) v1(131.43,10.14) v1(131.76,60.07) v1(132.14,10.14) v1(132.52,60.07) v1(133.28,65.01) v1(133.48,63.42) v1(133.56,10.14) v1(133.71,64.45) v1(134.37,10.14) v1(135.19,10.14) v1(136,10.14) v1(136.44,55.14) v1(136.44,54.42) v1(136.37,53.61) v1(136.41,50.24) v1(136.47,55.98) v1(136.48,52.72) v1(136.49,51.97) v1(136.46,51.21) v1(136.73,64.3) v1(136.79,49.23) v1(136.81,10.14) v1(137,48.28) v1(137.73,9.93) v1(138.08,49.14) v1(138.33,48.31) v1(138.39,47.12) v1(138.58,58.32) v1(139.05,9.93) v1(139.64,49.23) v1(139.7,62.88) v1(139.83,48.22) v1(139.78,46.97) v1(139.94,45.84) v1(139.86,9.93) v1(140.05,58.3) v1(140.78,59.11) v1(140.75,47.06) v1(140.99,44.81) v1(141.12,49.27) v1(141.18,45.81) v1(141.34,58.27) v1(141.33,48.24) v1(141.48,59.86) v1(141.59,10.14) v1(141.85,59.11) v1(142.02,44.83) v1(142,33.28) v1(142.27,45.78) v1(142.3,43.78) v1(142.43,58.28) v1(142.53,49.32) v1(142.5,10.14) v1(142.59,47.25) v1(143.13,58.87) v1(143.11,48.47) v1(143.11,30.01) v1(143.5,32.77) v1(143.5,32.27) v1(143.75,49.28) v1(143.87,30.01) v1(143.99,58.23) v1(144.34,58.88) v1(144.34,48.46) v1(144.83,56.7) v1(144.82,55.96) v1(144.78,55.12) v1(144.78,54.4) v1(144.79,53.63) v1(144.83,52.7) v1(144.84,51.95) v1(144.81,51.19) v1(144.92,49.27) v1(145.13,58.29) v1(145.45,50.25) v1(145.87,57.61) v1(145.9,56.73) v1(145.86,56) v1(145.9,55.17) v1(145.88,54.42) v1(145.87,53.6) v1(145.89,52.79) v1(145.94,52) v1(145.91,51.24) v1(145.91,35.66) v1(145.96,48.41) v1(146.15,58.35) v1(146.21,49.28) v1(146.28,53.63) v1(146.41,59.02) v1(146.4,56.74) v1(146.38,56) v1(146.35,55.16) v1(146.35,54.45) v1(146.4,52.75) v1(146.41,52) v1(146.37,51.23) v1(146.8,57.64) v1(146.87,50.25) v1(147.04,53.64) v1(147.15,56.75) v1(147.13,56.01) v1(147.1,55.18) v1(147.1,54.46) v1(147.15,52.76) v1(147.12,51.25) v1(147.16,52.01) v1(147.37,58.27) v1(147.66,59.57) v1(147.75,57.64) v1(147.83,50.24) v1(148.04,53.64) v1(148.14,56.01) v1(148.11,55.18) v1(148.11,54.46) v1(148.13,51.25) v1(148.15,56.75) v1(148.15,52.76) v1(148.16,52.01) v1(148.42,58.32) v1(148.69,59.64) v1(148.74,57.66) v1(149.02,55.19) v1(149.02,54.47) v1(148.96,53.65) v1(149.04,51.26) v1(149.07,56.76) v1(149.06,56.03) v1(149.07,52.77) v1(149.08,52.02) v1(149.1,50.19) v1(149.51,59.6) v1(149.6,57.7) v1(149.87,58.85) v1(150.6,59.37) v1(151,60.41) v2(5.24,33.69) v2(5.24,31.93) v2(5.22,30.51) v2(5.24,28.99) v2(5.22,27.44) v2(5.22,25.86) v2(5.27,35.41) v2(6.08,33.33) v2(6.08,30.97) v2(6.08,29.17) v2(6.1,28.05) v2(6.13,26.3) v2(6.21,24.87) v2(6.71,36.63) v2(7.15,35.95) v2(7.17,23.2) v2(7.63,24.01) v2(7.88,22.43) v2(8.26,23.45) v2(9,22.69) v2(9.69,21.65) v2(10.3,20.94) v2(10.35,19.89) v2(10.35,18.7) v2(10.37,15.35) v2(10.73,23.15) v2(11.59,22.13) v2(11.64,14.03) v2(12.02,20.73) v2(12.17,18.42) v2(12.33,15.68) v2(12.28,13.09) v2(13.27,14.71) v2(13.42,24.16) v2(13.55,11.99) v2(13.64,15.3) v2(13.64,14.92) v2(13.64,14.54) v2(13.72,11.21) v2(14.05,13.93) v2(14.18,10.24) v2(14.87,9.58) v2(15.4,11.74) v2(15.38,11.41) v2(15.53,8.92) v2(15.95,28.11) v2(15.93,13.44) v2(16.04,10.8) v2(16.54,7.83) v2(16.98,9.86) v2(17.18,6.64) v2(17.18,4.2) v2(17.53,3.08) v2(17.84,15.6) v2(17.84,14.79) v2(17.79,9.12) v2(18.45,15.6) v2(18.45,14.79) v2(18.83,5.72) v2(18.78,1.86) v2(18.93,33.38) v2(18.93,32.95) v2(18.86,5.09) v2(19.46,17.84) v2(19.46,17.02) v2(19.67,12.35) v2(19.9,1.3) v2(20.07,17.84) v2(20.07,17.02) v2(20.3,3.03) v2(20.58,20.07) v2(20.58,19.77) v2(21.09,3.03) v2(21.42,1.3) v2(21.5,3.03) v2(22.51,5.44) v2(22.51,2.98) v2(22.94,1.3) v2(23.1,3) v2(23.25,33.41) v2(23.5,0.86) v2(24.03,28.12) v2(24.34,30.38) v2(24.37,32.14) v2(24.47,1.3) v2(24.62,3) v2(25.99,1.3) v2(26.14,3) v2(27.52,1.3) v2(27.67,3) v2(29.04,1.3) v2(29.19,3) v2(30.56,1.3) v2(30.72,3) v2(32.09,1.3) v2(32.24,3) v2(33.1,18.98) v2(33.61,1.3) v2(33.82,2.98) v2(34.83,2.9) v2(35.14,1.3) v2(36.36,2.9) v2(36.66,1.3) v2(38.18,1.3) v2(38.56,18.33) v2(39.71,1.3) v2(41.23,1.3) v2(42.76,1.3) v2(44.28,1.3) v2(45.8,1.3) v2(47.33,1.3) v2(48.6,2.98) v2(48.85,1.3) v2(49.82,3) v2(50.38,1.3) v2(51.52,3) v2(51.9,1.3) v2(52.99,3.05) v2(53.42,1.3) v2(53.83,3.89) v2(54.11,1.78) v2(54.69,4.76) v2(54.9,2.57) v2(54.98,17.91) v2(54.98,17.41) v2(54.98,16.9) v2(55.48,17.91) v2(55.48,17.41) v2(55.48,16.9) v2(55.71,5.06) v2(55.84,3.46) v2(55.98,17.91) v2(55.98,17.41) v2(55.98,16.9) v2(58.4,4.63) v2(58.56,2.83) v2(59.7,4.45) v2(60.46,2.83) v2(61.35,15.6) v2(62.59,37.98) v2(62.59,37.47) v2(63.05,1.76) v2(63.36,37.98) v2(63.36,37.47) v2(64.63,36.46) v2(64.63,35.82) v2(64.58,1.76) v2(65.39,36.46) v2(65.39,35.82) v2(66.02,22.82) v2(66.02,22.56) v2(66.1,1.76) v2(66.68,22.82) v2(66.68,22.56) v2(67.62,1.76) v2(67.88,21.27) v2(67.88,21.01) v2(68.54,21.27) v2(68.54,21.01) v2(69.15,1.76) v2(70.67,1.76) v2(72.2,1.76) v2(73.64,1.76) v2(74.79,50.35) v2(74.84,49.23) v2(74.81,34.91) v2(74.86,50.98) v2(75.17,59.01) v2(75.17,55.56) v2(75.19,54.92) v2(75.34,53.57) v2(75.34,52.28) v2(75.27,3.13) v2(75.4,58.12) v2(75.37,57.38) v2(75.37,56.52) v2(75.62,3.49) v2(75.83,54.72) v2(75.83,52.36) v2(75.83,51.67) v2(75.83,48.77) v2(75.83,48.01) v2(75.93,55.71) v2(75.85,53.98) v2(75.85,53.09) v2(75.88,50.98) v2(75.88,50.2) v2(75.88,49.59) v2(76.06,3.94) v2(76.56,5.34) v2(77.07,5.92) v2(77.22,52.54) v2(77.33,53.63) v2(77.63,55.05) v2(77.63,52.62) v2(77.83,6.64) v2(77.96,56.05) v2(78.82,57.98) v2(78.82,56.96) v2(78.85,7.68) v2(79.89,54.22) v2(80.35,9.12) v2(81.41,29.91) v2(81.41,29.65) v2(81.41,29.4) v2(81.41,29.15) v2(81.41,28.89) v2(81.39,28.64) v2(81.39,28.38) v2(81.9,9.68) v2(82.33,30.03) v2(82.33,29.75) v2(82.33,29.5) v2(82.33,29.24) v2(82.36,28.99) v2(82.86,30.06) v2(82.86,29.76) v2(83.17,59.45) v2(83.16,30.06) v2(83.16,29.76) v2(83.43,37.16) v2(83.42,30.06) v2(83.42,29.73) v2(84.01,9.63) v2(84.33,59.58) v2(84.33,32.4) v2(84.26,31.79) v2(84.26,28.77) v2(84.64,59.37) v2(84.62,30.92) v2(85.58,8.54) v2(85.88,29.73) v2(86.48,52.42) v2(86.6,30.82) v2(86.67,59.47) v2(86.77,7.35) v2(87.18,59.47) v2(87.2,52.69) v2(87.61,59.5) v2(87.77,8.67) v2(88.07,59.5) v2(88.25,7.02) v2(88.74,53.71) v2(89.16,54.32) v2(89.31,6.99) v2(89.44,53.71) v2(93.58,31.2) v2(93.63,30.94) v2(93.84,31.43) v2(93.84,30.75) v2(94.04,55.77) v2(94.04,55.51) v2(94.01,49.12) v2(94.01,48.87) v2(94.09,55.26) v2(94.09,31.4) v2(94.29,55.51) v2(94.34,55.26) v2(94.34,31.4) v2(94.34,30.72) v2(94.65,49.11) v2(94.65,48.86) v2(94.6,31.4) v2(94.6,30.71) v2(94.6,28.38) v2(94.6,28.12) v2(94.85,28.4) v2(94.85,28.12) v2(95.11,28.41) v2(95.11,28.13) v2(95.08,27.87) v2(95.36,28.4) v2(95.36,28.15) v2(97.11,23.02) v2(98.98,33.15) v2(99.09,32.92) v2(99.23,33.18) v2(99.37,33.56) v2(99.55,32.96) v2(100.52,39.92) v2(100.52,39.61) v2(100.52,39.33) v2(102.57,35.74) v2(102.83,35.88) v2(102.88,23.35) v2(103.31,46.82) v2(103.34,46.36) v2(103.28,44.26) v2(103.34,31.76) v2(103.46,29.85) v2(103.59,32.83) v2(103.61,32.5) v2(103.74,23.32) v2(103.86,32.85) v2(103.86,32.55) v2(104.05,43.93) v2(104.15,44.3) v2(104.14,32.83) v2(104.12,32.55) v2(109.49,32.75) v2(109.48,31.26) v2(109.68,31.92) v2(109.68,31.66) v2(109.68,31.41) v2(110.83,50.41) v2(110.85,41.1) v2(110.98,30.61) v2(110.98,29.98) v2(111.18,50.48) v2(111.42,30.3) v2(111.57,50.68) v2(111.57,38.94) v2(111.74,35.64) v2(111.79,40.19) v2(111.87,29.98) v2(112.12,43.47) v2(112.12,43.21) v2(112.12,42.96) v2(112.35,43.35) v2(112.35,43.08) v2(112.35,42.83) v2(113.34,57.32) v2(115.42,34.76) v2(116.06,37.6) v2(117.86,30.33) v2(117.86,29.5) v2(124.84,49.92) v2(124.9,37.52) v2(125.34,49.92) v2(125.28,37.52) v2(125.84,49.92) v2(128.76,20.55) v2(130.34,65.46) v2(130.4,67.02) v2(130.41,20.55) v2(131.05,65.47) v2(131.1,67.03) v2(131.71,67.03) v2(131.66,65.47) v2(131.76,60.07) v2(132.35,65.47) v2(132.4,67.03) v2(132.52,60.07) v2(133.28,65.01) v2(133.4,67.03) v2(133.41,65.66) v2(133.48,63.42) v2(133.71,64.45) v2(134.09,67.03) v2(134.1,65.66) v2(134.8,67.05) v2(134.94,65.15) v2(135.49,67.04) v2(135.63,65.14) v2(136.44,55.14) v2(136.44,54.42) v2(136.37,53.61) v2(136.41,50.24) v2(136.47,55.98) v2(136.48,52.72) v2(136.49,51.97) v2(136.46,51.21) v2(136.73,64.3) v2(136.69,56.75) v2(136.79,49.23) v2(137,48.28) v2(137.2,53.61) v2(137.31,56.72) v2(137.3,55.98) v2(137.27,55.14) v2(137.27,54.42) v2(137.31,52.72) v2(137.32,51.97) v2(137.29,51.21) v2(137.72,50.24) v2(137.83,57.54) v2(138.04,53.6) v2(138.15,56.71) v2(138.14,55.97) v2(138.1,55.13) v2(138.1,54.41) v2(138.15,52.71) v2(138.13,51.2) v2(138.08,49.14) v2(138.16,51.96) v2(138.33,48.31) v2(138.39,47.12) v2(138.47,66.49) v2(138.58,58.32) v2(138.89,53.61) v2(139,56.72) v2(138.99,55.98) v2(138.96,55.14) v2(138.96,54.42) v2(139,52.72) v2(139.01,51.97) v2(138.98,51.21) v2(139.1,50.25) v2(139.16,66.49) v2(139.3,57.5) v2(139.64,49.23) v2(139.7,62.88) v2(139.69,53.62) v2(139.81,56.73) v2(139.79,55.99) v2(139.76,55.15) v2(139.76,54.44) v2(139.8,52.74) v2(139.82,51.98) v2(139.78,51.22) v2(139.83,48.22) v2(139.78,46.97) v2(139.94,45.84) v2(140.05,58.3) v2(140.37,50.34) v2(140.62,55.16) v2(140.62,54.45) v2(140.56,53.63) v2(140.64,51.23) v2(140.74,57.55) v2(140.67,56.74) v2(140.66,56) v2(140.67,52.75) v2(140.68,52) v2(140.78,59.11) v2(140.75,47.06) v2(140.99,44.81) v2(141.12,49.27) v2(141.18,45.81) v2(141.34,58.27) v2(141.33,48.24) v2(141.45,56.04) v2(141.42,55.2) v2(141.42,54.48) v2(141.35,53.66) v2(141.44,51.27) v2(141.48,59.86) v2(141.46,56.78) v2(141.46,52.78) v2(141.47,52.03) v2(141.85,59.11) v2(141.76,50.2) v2(141.88,57.56) v2(142.02,44.83) v2(142.24,55.16) v2(142.24,54.45) v2(142.18,53.63) v2(142.29,56.74) v2(142.28,56) v2(142.29,52.75) v2(142.3,52) v2(142.27,51.23) v2(142.27,45.78) v2(142.3,43.78) v2(142.43,58.28) v2(142.53,49.32) v2(142.59,47.25) v2(143.02,55.18) v2(143.02,54.46) v2(142.95,53.64) v2(143.04,51.25) v2(142.97,50.23) v2(143.13,58.87) v2(143.06,56.75) v2(143.05,56.01) v2(143.06,52.76) v2(143.07,52.01) v2(143.11,48.47) v2(143.24,57.56) v2(143.75,49.28) v2(143.85,53.64) v2(143.94,56.01) v2(143.91,55.18) v2(143.91,54.46) v2(143.93,51.25) v2(143.99,58.23) v2(143.96,56.75) v2(143.96,52.76) v2(143.97,52.01) v2(144.12,50.28) v2(144.34,58.88) v2(144.34,48.46) v2(144.51,57.6) v2(144.83,56.7) v2(144.82,55.96) v2(144.78,55.12) v2(144.78,54.4) v2(144.79,53.63) v2(144.83,52.7) v2(144.84,51.95) v2(144.81,51.19) v2(144.92,49.27) v2(145.13,58.29) v2(145.45,50.25) v2(145.87,57.61) v2(145.9,56.73) v2(145.86,56) v2(145.9,55.17) v2(145.88,54.42) v2(145.87,53.6) v2(145.89,52.79) v2(145.94,52) v2(145.91,51.24) v2(145.96,48.41) v2(146.15,58.35) v2(146.21,49.28) v2(146.28,53.63) v2(146.41,59.02) v2(146.4,56.74) v2(146.38,56) v2(146.35,55.16) v2(146.35,54.45) v2(146.4,52.75) v2(146.41,52) v2(146.37,51.23) v2(146.8,57.64) v2(146.87,50.25) v2(147.04,53.64) v2(147.15,56.75) v2(147.13,56.01) v2(147.1,55.18) v2(147.1,54.46) v2(147.15,52.76) v2(147.12,51.25) v2(147.16,52.01) v2(147.37,58.27) v2(147.66,59.57) v2(147.75,57.64) v2(147.83,50.24) v2(148.04,53.64) v2(148.14,56.01) v2(148.11,55.18) v2(148.11,54.46) v2(148.13,51.25) v2(148.15,56.75) v2(148.15,52.76) v2(148.16,52.01) v2(148.42,58.32) v2(148.69,59.64) v2(148.74,57.66) v2(149.02,55.19) v2(149.02,54.47) v2(148.96,53.65) v2(149.04,51.26) v2(149.07,56.76) v2(149.06,56.03) v2(149.07,52.77) v2(149.08,52.02) v2(149.1,50.19) v2(149.51,59.6) v2(149.6,57.7) v2(149.87,58.85) v2(150.6,59.37) v2(151,60.41) v3(13.53,28.59) v3(16.98,32.44) v3(17.84,15.2) v3(18.02,32.14) v3(18.45,15.2) v3(19.46,17.43) v3(19.87,17.43) v3(24.52,42.5) v3(24.7,43.77) v3(26.25,41.62) v3(26.57,5.62) v3(27.34,45.14) v3(28,4.12) v3(28.91,5.14) v3(29.83,4.12) v3(30.08,14.84) v3(32.11,14.84) v3(32.39,19.16) v3(33.92,15.8) v3(38.84,18.14) v3(55.23,17.66) v3(55.23,17.15) v3(55.74,17.63) v3(55.74,17.15) v3(62.97,37.98) v3(62.97,37.47) v3(63.28,19.59) v3(63.41,43.44) v3(64.09,43.85) v3(64.55,19.59) v3(64.75,41.23) v3(65.01,36.38) v3(65.01,35.9) v3(65.13,41.05) v3(66.38,22.69) v3(66.35,19.61) v3(66.71,44.18) v3(68.23,21.14) v3(69.92,22.79) v3(70.26,23.02) v3(75.9,55.31) v3(79.15,40.9) v3(79.86,50.98) v3(80.39,55.7) v3(81.09,29.8) v3(81.09,29.39) v3(81.06,28.99) v3(81.4,47.16) v3(82.02,29.88) v3(82.02,29.37) v3(82.1,34.58) v3(82.1,34.1) v3(82.68,39.41) v3(82.72,38.73) v3(82.86,51.01) v3(83.17,40.27) v3(83.24,39.41) v3(83.2,38.73) v3(83.34,36.54) v3(83.73,30.26) v3(83.73,29.85) v3(83.78,40.45) v3(83.88,38.8) v3(83.92,36.49) v3(84.16,40.04) v3(84.16,39.23) v3(84.18,28.44) v3(84.59,38.65) v3(84.58,36.54) v3(84.84,34.23) v3(85.35,37.95) v3(85.28,36.37) v3(85.43,38.77) v3(85.37,37.16) v3(85.53,40.07) v3(85.77,39.22) v3(86.1,53.9) v3(86.06,36.5) v3(86.16,40.44) v3(86.85,55.88) v3(87.05,38.75) v3(87.08,40.31) v3(87.07,39.6) v3(87.37,39.94) v3(87.38,39.09) v3(87.37,37.5) v3(88.14,50.93) v3(88.3,46.58) v3(88.63,38.69) v3(89.71,47.19) v3(90.22,52.71) v3(90.68,54.19) v3(90.95,55.08) v3(91.38,56.54) v3(91.39,53.41) v3(92.28,53.49) v3(93.73,55.64) v3(93.76,55.23) v3(93.94,56.22) v3(93.94,31.1) v3(94.34,48.98) v3(94.34,31.07) v3(94.27,28.33) v3(94.75,31.07) v3(95.74,52.84) v3(101.24,39.33) v3(101.23,36.56) v3(102.37,31.69) v3(103.21,33.51) v3(103.31,36.58) v3(103.26,32.8) v3(103.28,32.24) v3(104.58,43.62) v3(105.93,31.02) v3(106.28,38.69) v3(109.3,32.17) v3(109.3,31.71) v3(109.51,36.64) v3(109.66,41.8) v3(109.71,39.99) v3(110.11,31.87) v3(110.11,31.36) v3(110.55,41.33) v3(110.68,30.8) v3(110.68,30.34) v3(110.8,50.81) v3(111.13,38.8) v3(111.21,50.81) v3(111.62,34.83) v3(111.64,30.7) v3(111.79,43.57) v3(111.82,35.27) v3(112.14,43.81) v3(112.4,50.27) v3(112.68,43.32) v3(112.68,42.91) v3(113.05,50.56) v3(114.15,34.41) v3(122.16,65.16) v3(123.71,28.15) v3(123.71,27.59) v3(123.71,27.03) v3(123.81,29.37) v3(125.08,37.83) v3(125.33,29.47) v3(125.33,28.45) v3(125.41,50.27) v3(125.84,50.27) v3(125.84,29.47) v3(125.84,28.45) v3(126.14,28.96) v3(126.35,29.47) v3(126.55,58.63) v3(127.31,29.47) v3(127.41,28.96) v3(127.36,28.45) v3(129.4,20.22) v3(130.03,20.22) v3(130.7,65.47) v3(130.72,38.92) v3(130.72,38.31) v3(130.72,37.75) v3(130.76,67.03) v3(131.22,38.92) v3(131.28,37.7) v3(131.75,59.71) v3(131.83,38.36) v3(131.83,37.7) v3(132.01,65.48) v3(132.06,67.04) v3(132.49,59.7) v3(133.74,67.04) v3(133.75,65.68) v3(135.14,67.04) v3(135.28,65.14) v3(136.38,64.33) v3(136.84,56.44) v3(136.84,55.56) v3(136.84,54.79) v3(136.93,50.24) v3(136.97,53.27) v3(136.97,52.38) v3(137.19,51.59) v3(137.28,49.2) v3(137.5,41.76) v3(137.56,48.29) v3(137.73,56.44) v3(137.69,55.66) v3(137.73,54.79) v3(137.85,53.27) v3(137.85,52.38) v3(137.85,51.62) v3(138.39,57.62) v3(138.62,56.44) v3(138.62,55.56) v3(138.62,54.79) v3(138.56,50.23) v3(138.74,53.27) v3(138.74,52.38) v3(138.81,66.51) v3(138.79,51.62) v3(138.81,49.2) v3(139.18,48.29) v3(139.68,50.31) v3(139.99,57.64) v3(140.14,56.44) v3(140.14,55.56) v3(140.14,54.79) v3(140.14,53.27) v3(140.14,52.38) v3(140.14,51.62) v3(140.38,49.29) v3(140.85,48.22) v3(141.03,56.44) v3(141.03,55.56) v3(141.03,54.79) v3(141.03,53.27) v3(141.03,52.38) v3(141.03,51.62) v3(141.06,50.31) v3(141.33,57.79) v3(141.73,49.3) v3(141.84,48.26) v3(141.92,56.44) v3(141.92,55.56) v3(141.92,54.79) v3(141.92,53.27) v3(141.92,52.38) v3(141.92,51.62) v3(142.37,50.23) v3(142.67,57.79) v3(143.13,49.28) v3(143.44,56.39) v3(143.44,55.56) v3(143.44,54.79) v3(143.44,53.27) v3(143.44,52.38) v3(143.44,51.62) v3(143.46,50.22) v3(143.66,57.81) v3(144.33,56.39) v3(144.33,55.56) v3(144.33,54.79) v3(144.33,53.27) v3(144.33,52.38) v3(144.33,51.62) v3(144.51,41.81) v3(144.81,50.31) v3(145.04,32.95) v3(145.09,57.83) v3(145.22,56.39) v3(145.22,55.56) v3(145.22,54.79) v3(145.22,53.27) v3(145.22,52.38) v3(145.22,51.62) v3(145.95,50.26) v3(146.16,40.01) v3(146.28,57.81) v3(146.74,56.39) v3(146.74,55.56) v3(146.74,54.79) v3(146.74,53.27) v3(146.74,52.38) v3(146.74,51.62) v3(146.79,39) v3(147.31,57.82) v3(147.26,50.27) v3(147.63,56.39) v3(147.63,55.56) v3(147.63,54.79) v3(147.63,53.27) v3(147.63,52.38) v3(147.63,51.62) v3(148.15,57.87) v3(148.38,50.23) v3(148.52,56.39) v3(148.52,55.56) v3(148.52,54.79) v3(148.52,53.27) v3(148.52,52.38) v3(148.52,51.62) v3(148.77,58.1) v3(150.68,58.43) v3(150.68,57.59) v3(150.68,56.83) v3(150.68,55.89) v3(150.68,55.05) v3(150.68,54.29) v3(150.68,53.6) v3(150.68,52.76) v3(150.68,52) v3(150.68,51.19) v3(150.68,50.35) v3(150.68,49.59) v4(9.45,51.61) v4(9.63,58.68) v4(10.3,52) v4(14.38,25.51) v4(14.64,25.74) v4(17.84,15.6) v4(17.84,14.79) v4(18.45,15.6) v4(18.45,14.79) v4(19.46,17.84) v4(19.46,17.02) v4(20.07,17.84) v4(20.07,17.02) v4(21.14,19.75) v4(21.6,17.41) v4(21.6,16.64) v4(21.9,19.75) v4(21.98,42.22) v4(22.18,42.4) v4(23.07,17.33) v4(23.07,16.64) v4(23.38,28.96) v4(23.38,28.2) v4(23.5,25.15) v4(23.6,18.17) v4(23.6,17.86) v4(23.6,17.58) v4(23.7,23.88) v4(23.7,22.74) v4(23.7,21.6) v4(23.86,41.28) v4(23.89,26.55) v4(25.51,41.96) v4(26.98,45.35) v4(27.09,27.7) v4(27.64,16.84) v4(28.41,16.84) v4(28.81,41.99) v4(28.81,41.69) v4(28.81,41.3) v4(28.81,40.9) v4(31.22,17.38) v4(31.48,41.89) v4(31.48,41.54) v4(31.9,41.9) v4(31.89,41.54) v4(32.11,17.38) v4(32.27,41.89) v4(32.27,41.54) v4(33.16,24.26) v4(33.16,23.5) v4(33.16,22.23) v4(34.43,34.58) v4(41.16,11.31) v4(41.26,33.44) v4(42.18,19.06) v4(42.94,33) v4(44.05,36.25) v4(44.91,11.31) v4(46.05,36.25) v4(46.69,32.72) v4(47.58,34.08) v4(47.76,17.41) v4(48.57,31.98) v4(50.24,30.74) v4(50.24,30.49) v4(51.44,32.85) v4(51.39,16.54) v4(54.08,10.01) v4(54.16,18.42) v4(55.25,42.3) v4(55.25,41.89) v4(55.69,42.3) v4(55.7,41.9) v4(56.14,42.3) v4(56.14,41.87) v4(56.65,9.25) v4(57.29,44.1) v4(57.44,48.1) v4(57.44,47.83) v4(57.49,44.29) v4(57.69,48.09) v4(57.69,47.83) v4(59.19,26.83) v4(59.37,27.01) v4(62.06,14.99) v4(62.29,20.17) v4(63.2,40.36) v4(63.76,43.68) v4(63.89,19.56) v4(64.55,36.28) v4(64.55,35.9) v4(64.75,40.77) v4(64.88,40.39) v4(64.88,40.01) v4(64.92,17.51) v4(64.92,17.25) v4(65.01,22.87) v4(65.46,41.11) v4(65.48,40.34) v4(65.46,36.3) v4(65.46,35.92) v4(65.72,19.62) v4(66.02,22.82) v4(66.02,22.56) v4(66.58,41.51) v4(66.68,22.82) v4(66.68,22.56) v4(66.94,42.62) v4(66.86,19.62) v4(67.02,43.41) v4(67.37,40.61) v4(67.93,21.27) v4(67.93,21.01) v4(68.54,21.27) v4(68.54,21.01) v4(69.35,22.46) v4(69.56,22.6) v4(69.78,22.46) v4(70.05,22.46) v4(79.97,53.17) v4(80.58,42.25) v4(80.58,42) v4(80.58,40.98) v4(80.58,40.73) v4(80.58,39.71) v4(80.58,39.46) v4(81.08,49.5) v4(81.26,38.47) v4(82.08,55.55) v4(82.3,41.06) v4(82.31,40.81) v4(82.35,34.36) v4(82.48,34.13) v4(82.56,41.06) v4(82.56,40.81) v4(82.67,52.28) v4(82.89,39.03) v4(83.22,42.4) v4(83.32,40.8) v4(83.45,37.13) v4(83.53,38.74) v4(83.63,48.6) v4(83.61,36.33) v4(83.65,36.69) v4(84.06,41.77) v4(84.25,38.74) v4(84.31,56.42) v4(84.64,42.89) v4(85.03,41.09) v4(85.02,37.13) v4(85.22,38.37) v4(85.3,42.46) v4(85.45,43.19) v4(85.61,40.4) v4(86.22,36.19) v4(86.62,40.89) v4(86.75,38.61) v4(86.91,34.76) v4(86.97,49.13) v4(87.29,55.74) v4(87.49,43.09) v4(87.46,41.9) v4(87.71,43.37) v4(88.17,46.27) v4(88.42,46.27) v4(88.54,53.19) v4(88.91,35.67) v4(89.1,39.82) v4(89.11,39.12) v4(89.33,54.01) v4(89.41,46.6) v4(89.41,46.34) v4(89.42,35.62) v4(89.67,35.62) v4(89.78,49.2) v4(90.23,35.82) v4(90.48,35.82) v4(90.76,49.14) v4(90.97,52.4) v4(91.02,49.14) v4(91.09,31.53) v4(91.16,50.24) v4(91.35,31.53) v4(91.4,39.03) v4(91.7,46.6) v4(91.7,46.34) v4(91.65,39) v4(92.36,31.53) v4(92.55,53.86) v4(92.62,31.53) v4(93.07,36.25) v4(93.18,31.64) v4(93.18,31.25) v4(94.7,31.66) v4(94.82,31.43) v4(94.88,38.19) v4(94.95,31.65) v4(95.66,38.8) v4(97.04,43.9) v4(100.39,34.09) v4(100.39,33.82) v4(102.78,33.92) v4(102.93,37.94) v4(102.88,35.01) v4(103.51,46.19) v4(103.49,45.4) v4(103.51,44.46) v4(103.67,40.9) v4(103.92,45.83) v4(103.89,45.05) v4(103.92,44.11) v4(104.25,45.5) v4(104.27,46.29) v4(104.27,44.56) v4(104.66,36.06) v4(106.21,34.05) v4(106.33,33.41) v4(106.84,34.15) v4(107.42,36.97) v4(107.5,35.87) v4(108.58,56.01) v4(108.85,32.22) v4(108.85,31.97) v4(109.43,46.22) v4(109.36,35.41) v4(109.46,45.22) v4(109.51,36.99) v4(109.99,41.39) v4(110.14,47) v4(110.12,34.24) v4(110.35,45.12) v4(110.83,46.24) v4(111.01,47.23) v4(111.06,31.97) v4(111.06,31.71) v4(111.11,30.47) v4(111.11,30.21) v4(111.69,47) v4(112.12,35.14) v4(112.43,43.64) v4(112.58,44.02) v4(112.63,37.55) v4(112.73,37.05) v4(112.68,35.06) v4(112.89,35.52) v4(113.06,34.15) v4(115.2,65.35) v4(115.59,65.37) v4(116.47,14.85) v4(121.8,65.35) v4(123.38,28.28) v4(123.38,28.02) v4(123.38,27.72) v4(123.38,27.46) v4(123.45,26.73) v4(123.91,26.73) v4(124.6,65.24) v4(125,65.25) v4(125.2,29.09) v4(125.2,28.84) v4(125.46,29.09) v4(125.46,28.84) v4(126.47,29.09) v4(126.47,28.84) v4(126.73,29.09) v4(126.73,28.84) v4(127.74,29.09) v4(127.74,28.84) v4(128,29.09) v4(128,28.84) v4(129.42,56.83) v4(129.52,57.41) v4(129.52,57.16) v4(129.68,56.83) v4(129.68,56.57) v4(131.17,39.78) v4(131.17,39.48) v4(131.17,38.51) v4(131.17,38.21) v4(131.17,37.24) v4(131.17,36.94) v4(131.48,39.78) v4(131.48,39.48) v4(131.48,38.51) v4(131.48,38.21) v4(131.48,37.24) v4(131.48,36.94) v4(131.6,65.25) v4(132.85,41.61) v4(132.85,41.2) v4(133.33,41.61) v4(133.33,41.2) v4(134.89,55.26) v4(134.89,53.76) v4(134.89,52.26) v4(134.89,50.76) v4(135.24,48.34) v4(136.33,56.83) v4(136.33,56.06) v4(136.33,55.17) v4(136.33,54.41) v4(136.46,53.65) v4(136.46,52.89) v4(136.46,52) v4(136.46,51.24) v4(136.6,58.03) v4(136.81,57.55) v4(136.89,48.26) v4(137.22,56.83) v4(137.22,56.06) v4(137.22,55.17) v4(137.22,54.41) v4(137.35,53.65) v4(137.35,52.89) v4(137.35,52) v4(137.35,51.24) v4(137.42,50.27) v4(137.72,57.62) v4(137.99,49.21) v4(138.11,56.83) v4(138.11,56.06) v4(138.11,55.17) v4(138.11,54.41) v4(138.24,53.65) v4(138.24,52.89) v4(138.24,52) v4(138.24,51.24) v4(138.26,42.6) v4(138.26,42.35) v4(138.39,48.26) v4(138.54,42.6) v4(138.54,42.32) v4(138.57,58.16) v4(138.94,50.26) v4(139,57.62) v4(139,56.83) v4(139,56.06) v4(139,55.17) v4(139,54.41) v4(139.12,53.65) v4(139.12,52.89) v4(139.12,52) v4(139.12,51.24) v4(139.63,56.83) v4(139.63,56.06) v4(139.63,55.17) v4(139.63,54.41) v4(139.63,53.65) v4(139.63,52.89) v4(139.63,52) v4(139.63,51.24) v4(139.65,49.07) v4(139.89,48.26) v4(140.31,50.26) v4(140.52,56.83) v4(140.52,56.06) v4(140.52,55.17) v4(140.52,54.41) v4(140.52,53.65) v4(140.52,52.89) v4(140.52,52) v4(140.52,51.24) v4(140.77,57.69) v4(141.07,49.25) v4(141.41,56.83) v4(141.41,56.06) v4(141.41,55.17) v4(141.41,54.41) v4(141.41,53.65) v4(141.41,52.89) v4(141.41,52) v4(141.41,51.24) v4(141.39,48.26) v4(141.57,50.26) v4(142.05,57.7) v4(142.3,56.83) v4(142.3,56.06) v4(142.3,55.17) v4(142.3,54.41) v4(142.3,53.65) v4(142.3,52.89) v4(142.3,52) v4(142.3,51.24) v4(142.51,49.25) v4(142.93,56.83) v4(142.93,56.06) v4(142.93,55.17) v4(142.93,54.41) v4(142.93,53.65) v4(142.93,52.89) v4(142.93,52) v4(142.93,51.24) v4(142.95,50.25) v4(143.14,57.75) v4(143.66,49.26) v4(143.82,56.83) v4(143.82,56.06) v4(143.82,55.17) v4(143.82,54.41) v4(143.82,53.65) v4(143.82,52.89) v4(143.82,52) v4(143.82,51.24) v4(144.05,50.25) v4(144.26,57.74) v4(144.71,56.83) v4(144.71,56.06) v4(144.71,55.17) v4(144.71,54.41) v4(144.71,53.65) v4(144.71,52.89) v4(144.71,52) v4(144.71,51.24) v4(145.27,50.27) v4(145.6,56.83) v4(145.6,56.06) v4(145.6,55.17) v4(145.6,54.41) v4(145.6,53.65) v4(145.6,52.89) v4(145.6,52) v4(145.6,51.24) v4(145.65,57.78) v4(146.24,56.83) v4(146.24,56.06) v4(146.24,55.17) v4(146.24,54.41) v4(146.24,53.65) v4(146.24,52.89) v4(146.24,52) v4(146.24,51.24) v4(146.56,50.29) v4(146.78,57.8) v4(147.13,56.83) v4(147.13,56.06) v4(147.13,55.17) v4(147.13,54.41) v4(147.13,53.65) v4(147.13,52.89) v4(147.13,52) v4(147.13,51.24) v4(147.69,57.75) v4(147.77,50.3) v4(148.01,56.83) v4(148.01,56.06) v4(148.01,55.17) v4(148.01,54.41) v4(148.01,53.65) v4(148.01,52.89) v4(148.01,52) v4(148.01,51.24) v4(148.61,57.7) v4(148.9,56.83) v4(148.9,56.06) v4(148.9,55.17) v4(148.9,54.41) v4(148.9,53.65) v4(148.9,52.89) v4(148.9,52) v4(148.9,51.24) v4(148.9,50.28) v4(150.14,50.26) v4(150.17,59.37) v4(151.13,58.71) v4(151.13,58.21) v4(151.13,57.71) v4(151.13,57.21) v4(151.13,56.71) v4(151.13,56.21) v4(151.13,55.71) v4(151.13,55.21) v4(151.13,54.71) v4(151.13,54.21) v4(151.13,53.71) v4(151.13,53.21) v4(151.13,52.71) v4(151.13,52.21) v4(151.13,51.71) v4(151.13,51.21) v4(151.13,50.71) v4(151.13,50.21) v4(151.13,49.71) v4(151.13,49.21) v5(9.45,51.61) v5(9.63,58.68) v5(10.3,52) v5(14.38,25.51) v5(14.64,25.74) v5(17.84,15.6) v5(17.84,14.79) v5(18.45,15.6) v5(18.45,14.79) v5(19.46,17.84) v5(19.46,17.02) v5(20.07,17.84) v5(20.07,17.02) v5(21.14,19.75) v5(21.6,17.41) v5(21.6,16.64) v5(21.9,19.75) v5(21.98,42.22) v5(22.18,42.4) v5(23.07,17.33) v5(23.07,16.64) v5(23.38,28.96) v5(23.38,28.2) v5(23.5,25.15) v5(23.6,18.17) v5(23.6,17.86) v5(23.6,17.58) v5(23.7,23.88) v5(23.7,22.74) v5(23.7,21.6) v5(23.86,41.28) v5(23.89,26.55) v5(25.51,41.96) v5(26.98,45.35) v5(27.09,27.7) v5(27.64,16.84) v5(28.41,16.84) v5(28.81,41.99) v5(28.81,41.69) v5(28.81,41.3) v5(28.81,40.9) v5(31.22,17.38) v5(31.48,41.89) v5(31.48,41.54) v5(31.9,41.9) v5(31.89,41.54) v5(32.11,17.38) v5(32.27,41.89) v5(32.27,41.54) v5(33.16,24.26) v5(33.16,23.5) v5(33.16,22.23) v5(34.43,34.58) v5(37.32,23.37) v5(41.16,11.31) v5(41.26,33.44) v5(42.18,19.06) v5(42.94,33) v5(44.05,36.25) v5(44.91,11.31) v5(46.05,36.25) v5(46.69,32.72) v5(47.58,34.08) v5(47.76,17.41) v5(48.57,31.98) v5(50.24,30.74) v5(50.24,30.49) v5(51.44,32.85) v5(51.39,16.54) v5(54.08,10.01) v5(54.16,18.42) v5(55.25,42.3) v5(55.25,41.89) v5(55.69,42.3) v5(55.7,41.9) v5(56.14,42.3) v5(56.14,41.87) v5(56.65,9.25) v5(57.29,44.1) v5(57.44,48.1) v5(57.44,47.83) v5(57.49,44.29) v5(57.69,48.09) v5(57.69,47.83) v5(59.19,26.83) v5(59.37,27.01) v5(62.06,14.99) v5(62.29,20.17) v5(63.2,40.36) v5(63.76,43.68) v5(63.89,19.56) v5(64.55,36.28) v5(64.55,35.9) v5(64.75,40.77) v5(64.88,40.39) v5(64.88,40.01) v5(64.92,17.51) v5(64.92,17.25) v5(65.01,22.87) v5(65.46,41.11) v5(65.48,40.34) v5(65.46,36.3) v5(65.46,35.92) v5(65.72,19.62) v5(66.02,22.82) v5(66.02,22.56) v5(66.58,41.51) v5(66.68,22.82) v5(66.68,22.56) v5(66.94,42.62) v5(66.86,19.62) v5(67.02,43.41) v5(67.37,40.61) v5(67.93,21.27) v5(67.93,21.01) v5(68.54,21.27) v5(68.54,21.01) v5(69.35,22.46) v5(69.56,22.6) v5(69.78,22.46) v5(70.05,22.46) v5(79.97,53.17) v5(80.17,49.87) v5(80.17,48.6) v5(80.27,47.64) v5(80.4,50.13) v5(80.4,48.86) v5(80.58,42.25) v5(80.58,42) v5(80.58,40.98) v5(80.58,40.73) v5(80.58,39.71) v5(80.58,39.46) v5(81.08,49.5) v5(81.26,38.47) v5(81.85,44.48) v5(81.85,44.17) v5(82.08,55.55) v5(82.12,44.49) v5(82.13,44.18) v5(82.3,41.06) v5(82.31,40.81) v5(82.35,34.36) v5(82.48,34.13) v5(82.49,33.87) v5(82.56,41.06) v5(82.56,40.81) v5(82.67,52.28) v5(82.89,39.03) v5(83.22,42.4) v5(83.32,40.8) v5(83.45,37.13) v5(83.53,38.74) v5(83.63,48.6) v5(83.61,36.33) v5(83.65,36.69) v5(84.06,41.77) v5(84.25,38.74) v5(84.31,56.42) v5(84.49,49.85) v5(84.46,34.1) v5(84.64,42.89) v5(85.03,41.09) v5(85.02,37.13) v5(85.22,38.37) v5(85.17,34.84) v5(85.3,42.46) v5(85.45,43.19) v5(85.61,40.4) v5(86.22,36.19) v5(86.62,40.89) v5(86.75,38.61) v5(86.91,34.76) v5(86.97,49.13) v5(87.29,55.74) v5(87.49,43.09) v5(87.46,41.9) v5(87.49,33.62) v5(87.71,43.37) v5(88.17,46.27) v5(88.42,46.27) v5(88.54,53.19) v5(88.91,35.67) v5(89.1,39.82) v5(89.11,39.12) v5(89.33,54.01) v5(89.41,46.6) v5(89.41,46.34) v5(89.42,35.62) v5(89.67,35.62) v5(89.78,49.2) v5(90.23,35.82) v5(90.48,35.82) v5(90.76,49.14) v5(90.97,52.4) v5(91.02,49.14) v5(91.09,31.53) v5(91.16,50.24) v5(91.35,31.53) v5(91.4,39.03) v5(91.7,46.6) v5(91.7,46.34) v5(91.65,39) v5(92.36,31.53) v5(92.55,53.86) v5(92.62,31.53) v5(93.07,36.25) v5(93.18,31.64) v5(93.18,31.25) v5(94.7,31.66) v5(94.82,31.43) v5(94.88,38.19) v5(94.95,31.65) v5(95.66,38.8) v5(97.04,43.9) v5(100.39,34.09) v5(100.39,33.82) v5(102.78,33.92) v5(103.51,46.19) v5(103.49,45.4) v5(103.51,44.46) v5(103.92,45.83) v5(103.89,45.05) v5(103.92,44.11) v5(104.25,45.5) v5(104.27,46.29) v5(104.27,44.56) v5(104.66,36.06) v5(104.88,39.74) v5(105.93,43.78) v5(106.21,34.05) v5(106.33,33.41) v5(106.84,34.15) v5(107.5,35.87) v5(108.18,40.35) v5(108.58,56.01) v5(108.85,32.22) v5(108.85,31.97) v5(109.43,46.22) v5(109.36,35.41) v5(109.46,45.22) v5(109.51,36.99) v5(109.99,41.39) v5(110.14,47) v5(110.12,34.24) v5(110.35,45.12) v5(110.83,46.24) v5(111.01,47.23) v5(111.06,31.97) v5(111.06,31.71) v5(111.11,30.47) v5(111.11,30.21) v5(112.12,35.14) v5(112.43,43.64) v5(112.58,44.02) v5(112.63,37.55) v5(112.68,35.06) v5(113.06,34.15) v5(115.2,65.35) v5(115.59,65.37) v5(116.47,14.85) v5(119.03,32.59) v5(119.41,32.62) v5(121.57,28.1) v5(121.57,27.69) v5(121.8,65.35) v5(122.03,27.94) v5(122.49,28.1) v5(122.49,27.69) v5(123.38,28.28) v5(123.38,28.02) v5(123.38,27.72) v5(123.38,27.46) v5(123.45,26.73) v5(123.91,26.73) v5(124.6,65.24) v5(125,65.25) v5(125.2,29.09) v5(125.2,28.84) v5(125.46,29.09) v5(125.46,28.84) v5(126.47,29.09) v5(126.47,28.84) v5(126.73,29.09) v5(126.73,28.84) v5(127.74,29.09) v5(127.74,28.84) v5(128,29.09) v5(128,28.84) v5(129.42,56.83) v5(129.52,57.41) v5(129.52,57.16) v5(129.68,56.83) v5(129.68,56.57) v5(131.17,39.78) v5(131.17,39.48) v5(131.17,38.51) v5(131.17,38.21) v5(131.17,37.24) v5(131.17,36.94) v5(131.48,39.78) v5(131.48,39.48) v5(131.48,38.51) v5(131.48,38.21) v5(131.48,37.24) v5(131.48,36.94) v5(131.6,65.25) v5(132.85,41.61) v5(132.85,41.2) v5(133.33,41.61) v5(133.33,41.2) v5(134.89,55.26) v5(134.89,53.76) v5(134.89,52.26) v5(134.89,50.76) v5(135.24,48.34) v5(136.33,56.83) v5(136.33,56.06) v5(136.33,55.17) v5(136.33,54.41) v5(136.46,53.65) v5(136.46,52.89) v5(136.46,52) v5(136.46,51.24) v5(136.89,48.26) v5(137.22,56.83) v5(137.22,56.06) v5(137.22,55.17) v5(137.22,54.41) v5(137.35,53.65) v5(137.35,52.89) v5(137.35,52) v5(137.35,51.24) v5(138.11,56.83) v5(138.11,56.06) v5(138.11,55.17) v5(138.11,54.41) v5(138.24,53.65) v5(138.24,52.89) v5(138.24,52) v5(138.24,51.24) v5(138.26,42.6) v5(138.26,42.35) v5(138.39,48.26) v5(138.54,42.6) v5(138.54,42.32) v5(139,56.83) v5(139,56.06) v5(139,55.17) v5(139,54.41) v5(139.12,53.65) v5(139.12,52.89) v5(139.12,52) v5(139.12,51.24) v5(139.63,56.83) v5(139.63,56.06) v5(139.63,55.17) v5(139.63,54.41) v5(139.63,53.65) v5(139.63,52.89) v5(139.63,52) v5(139.63,51.24) v5(139.89,48.26) v5(140.52,56.83) v5(140.52,56.06) v5(140.52,55.17) v5(140.52,54.41) v5(140.52,53.65) v5(140.52,52.89) v5(140.52,52) v5(140.52,51.24) v5(141.41,56.83) v5(141.41,56.06) v5(141.41,55.17) v5(141.41,54.41) v5(141.41,53.65) v5(141.41,52.89) v5(141.41,52) v5(141.41,51.24) v5(141.39,48.26) v5(142.3,56.83) v5(142.3,56.06) v5(142.3,55.17) v5(142.3,54.41) v5(142.3,53.65) v5(142.3,52.89) v5(142.3,52) v5(142.3,51.24) v5(142.93,56.83) v5(142.93,56.06) v5(142.93,55.17) v5(142.93,54.41) v5(142.93,53.65) v5(142.93,52.89) v5(142.93,52) v5(142.93,51.24) v5(143.82,56.83) v5(143.82,56.06) v5(143.82,55.17) v5(143.82,54.41) v5(143.82,53.65) v5(143.82,52.89) v5(143.82,52) v5(143.82,51.24) v5(144.71,56.83) v5(144.71,56.06) v5(144.71,55.17) v5(144.71,54.41) v5(144.71,53.65) v5(144.71,52.89) v5(144.71,52) v5(144.71,51.24) v5(145.6,56.83) v5(145.6,56.06) v5(145.6,55.17) v5(145.6,54.41) v5(145.6,53.65) v5(145.6,52.89) v5(145.6,52) v5(145.6,51.24) v5(146.24,56.83) v5(146.24,56.06) v5(146.24,55.17) v5(146.24,54.41) v5(146.24,53.65) v5(146.24,52.89) v5(146.24,52) v5(146.24,51.24) v5(147.13,56.83) v5(147.13,56.06) v5(147.13,55.17) v5(147.13,54.41) v5(147.13,53.65) v5(147.13,52.89) v5(147.13,52) v5(147.13,51.24) v5(148.01,56.83) v5(148.01,56.06) v5(148.01,55.17) v5(148.01,54.41) v5(148.01,53.65) v5(148.01,52.89) v5(148.01,52) v5(148.01,51.24) v5(148.9,56.83) v5(148.9,56.06) v5(148.9,55.17) v5(148.9,54.41) v5(148.9,53.65) v5(148.9,52.89) v5(148.9,52) v5(148.9,51.24) v5(150.17,59.37) v5(151.13,58.71) v5(151.13,58.21) v5(151.13,57.71) v5(151.13,57.21) v5(151.13,56.71) v5(151.13,56.21) v5(151.13,55.71) v5(151.13,55.21) v5(151.13,54.71) v5(151.13,54.21) v5(151.13,53.71) v5(151.13,53.21) v5(151.13,52.71) v5(151.13,52.21) v5(151.13,51.71) v5(151.13,51.21) v5(151.13,50.71) v5(151.13,50.21) v5(151.13,49.71) v5(151.13,49.21) v6(1.06,49.28) v6(3.04,35.62) v6(2.99,24.08) v6(3.12,37.76) v6(3.06,33.61) v6(3.14,28.05) v6(3.2,48.67) v6(3.15,30.42) v6(3.21,21.7) v6(4.5,62.5) v6(4.83,50.31) v6(6.77,48.65) v6(7.04,62.5) v6(7.97,19.51) v6(7.97,16.97) v6(7.97,14.43) v6(7.97,11.89) v6(7.97,9.35) v6(9.58,62.5) v6(10.97,48.67) v6(12.66,17.68) v6(13.72,16.97) v6(13.8,17.71) v6(13.78,16.26) v6(14.44,46.03) v6(14.46,44.19) v6(14.48,41.93) v6(14.51,39.59) v6(14.69,0.77) v6(16.52,0.77) v6(18.19,0.79) v6(18.41,53.31) v6(19.24,50.91) v6(19.31,30.64) v6(19.87,0.77) v6(20.3,29.6) v6(21.29,30.64) v6(21.4,0.77) v6(21.65,50.11) v6(22.92,0.77) v6(24.19,50.11) v6(24.8,21.7) v6(25.56,18.6) v6(25.76,5.95) v6(25.81,0.79) v6(26.73,50.11) v6(26.78,34.91) v6(26.78,31.4) v6(26.88,23.7) v6(26.91,21.09) v6(27.54,33.15) v6(28.23,31.4) v6(28.3,34.91) v6(28.35,0.79) v6(29.27,50.11) v6(30.89,0.79) v6(31.12,19.41) v6(31.17,21.22) v6(31.81,50.11) v6(31.99,18.09) v6(32.09,25.3) v6(32.09,21.88) v6(33.43,0.79) v6(34.35,50.11) v6(35.97,0.79) v6(36.89,50.11) v6(38.51,0.79) v6(39.1,28.94) v6(39.07,27.46) v6(39.43,50.11) v6(39.86,28.2) v6(41.05,0.79) v6(41.97,50.11) v6(43.59,0.79) v6(44.51,50.11) v6(46.13,0.79) v6(46.77,27.18) v6(47.05,50.11) v6(48.67,0.79) v6(49.59,50.11) v6(51.21,0.79) v6(51.98,42.88) v6(52.13,50.11) v6(52.1,42.17) v6(52.66,42.68) v6(53.4,42.17) v6(53.75,0.79) v6(54.67,50.11) v6(56.29,0.79) v6(57.21,50.11) v6(58.48,50.87) v6(58.73,5.06) v6(58.83,0.79) v6(59.3,52.14) v6(59.38,62.07) v6(59.39,60.13) v6(61.37,0.79) v6(63.91,0.79) v6(63.99,14.64) v6(64.7,14.64) v6(65.51,14.64) v6(66.45,0.79) v6(66.58,13.57) v6(66.99,14.15) v6(67.14,27.95) v6(67.45,13.6) v6(67.97,68.71) v6(67.95,29.29) v6(68.44,27.95) v6(68.74,29.29) v6(68.99,0.79) v6(69.25,7.98) v6(69.25,7.27) v6(69.53,29.29) v6(69.58,27.97) v6(70.1,68.72) v6(71.53,0.79) v6(72.03,68.67) v6(74.15,68.72) v6(74.07,0.79) v6(76.29,68.71) v6(76.61,0.79) v6(78.83,68.71) v6(81.37,68.71) v6(83.91,68.71) v6(86.45,68.71) v6(88.99,68.71) v6(89.81,4.79) v6(91.53,68.71) v6(92.35,4.79) v6(94.07,68.71) v6(94.89,4.79) v6(96.61,68.71) v6(97.43,4.79) v6(99.15,68.71) v6(99.7,18.37) v6(99.67,17.65) v6(99.97,4.79) v6(100.26,9.53) v6(100.41,18.37) v6(100.39,17.66) v6(100.97,9.53) v6(101.69,68.71) v6(101.68,9.53) v6(102.4,9.53) v6(102.51,4.79) v6(103.11,9.53) v6(103.82,9.53) v6(104.23,68.71) v6(104.53,9.53) v6(105.05,4.79) v6(105.24,9.53) v6(105.95,9.53) v6(106.66,9.53) v6(106.77,68.71) v6(107.59,4.79) v6(109.31,68.71) v6(110.3,4.78) v6(111.85,68.71) v6(114.39,68.71) v6(116.93,68.71) v6(119.47,68.71) v6(121.39,16.01) v6(122.01,68.71) v6(123.68,31.35) v6(123.81,33.38) v6(124.52,32.39) v6(124.52,31.35) v6(124.55,68.71) v6(124.62,33.41) v6(124.66,6.31) v6(125.23,32.39) v6(125.23,31.38) v6(125.33,33.38) v6(125.39,4.82) v6(126.09,40.49) v6(126.47,68.71) v6(126.75,40.49) v6(127.41,40.49) v6(127.55,6.35) v6(128.08,40.49) v6(128.74,40.49) v6(128.72,4.86) v6(129.43,68.71) v6(130.4,6.34) v6(131.91,68.71) v6(131.99,4.84) v6(133.49,6.33) v6(134.33,68.72) v6(135.06,4.84) v6(136.6,6.35) v6(136.83,68.71) v6(138.15,4.77) v6(138.79,15.88) v6(139.14,6.35) v6(139.39,68.72) v6(140.7,15.88) v6(140.7,14.1) v6(141.06,4.77) v6(142.48,14.1) v6(142.55,15.88) v6(142.61,6.39) v6(144.13,4.79) v6(144.52,46.35) v6(145.13,6.44) v6(145.91,4.83) v6(146.27,10.9) v6(146.67,16.9) v6(148.09,8.11) v6(148.81,16.51) v6(148.83,6.68) v6(149.08,14.67) v6(150.01,11.3) v6(150.03,8.32) v6(150.12,27.79) v6(150.09,4.78) v6(150.76,28.45) v6(152.26,5.54) v6(152.42,64.13) v6(152.41,26.78) v6(152.46,62) v6(152.51,60.48) v6(152.51,58.48) v6(152.51,56.59) v6(152.54,54.62) v6(152.54,52.44) v6(152.54,50.39) v6(152.51,48.46) v6(152.51,46.69) v6(152.53,44.58) v6(152.49,42.42) v6(152.49,40.43) v6(152.51,38.57) v6(152.51,36.03) v6(152.51,33.49) v6(152.51,30.95) v6(152.51,28.41) v6(152.51,13.17) v6(152.51,10.63) v6(152.51,8.09) v7(80,50.7) v7(80.64,39.56) v7(80.64,39.16) v7(80.64,38.36) v7(80.64,37.96) v7(80.65,55.5) v7(81.03,39.56) v7(81.03,39.16) v7(81.03,38.36) v7(81.03,37.96) v7(81.03,37.56) v7(81.03,37.16) v7(81.31,47.49) v7(81.43,39.59) v7(81.43,39.16) v7(81.43,38.76) v7(81.43,38.36) v7(81.43,37.96) v7(81.43,37.56) v7(81.43,37.16) v7(81.83,39.56) v7(81.83,39.16) v7(81.83,38.76) v7(81.83,38.36) v7(81.83,37.96) v7(81.83,37.56) v7(81.83,37.16) v7(81.97,47.94) v7(82.24,39.56) v7(82.24,39.16) v7(82.24,38.76) v7(82.24,38.36) v7(82.24,37.96) v7(82.24,37.16) v7(82.61,50.7) v7(82.64,43.16) v7(82.58,39.99) v7(83.09,39.92) v7(83.24,39.56) v7(83.43,35.56) v7(83.83,39.96) v7(83.83,39.16) v7(83.83,36.36) v7(83.91,49.1) v7(84.24,40.76) v7(84.24,40.36) v7(84.24,39.56) v7(84.24,38.76) v7(84.24,37.96) v7(84.24,36.36) v7(84.24,34.36) v7(84.47,54.29) v7(84.56,49.89) v7(84.91,55.1) v7(85.03,37.16) v7(85.03,36.76) v7(85.03,35.96) v7(85.03,35.56) v7(85.03,35.16) v7(85.03,34.76) v7(85.43,40.76) v7(85.38,40.45) v7(85.43,39.16) v7(85.43,38.36) v7(85.43,37.56) v7(85.43,36.76) v7(85.53,40.27) v7(85.53,39.64) v7(85.47,38.83) v7(85.83,40.36) v7(85.83,39.56) v7(85.75,39.23) v7(85.83,38.76) v7(85.76,38.27) v7(85.83,37.96) v7(85.75,37.63) v7(85.81,37.17) v7(85.83,36.36) v7(85.83,34.33) v7(86.51,55.5) v7(86.51,53.89) v7(86.48,52.42) v7(86.83,50.22) v7(86.82,48.52) v7(87.03,37.56) v7(87,37.2) v7(87.03,36.76) v7(87.03,35.96) v7(87,35.55) v7(87.03,35.16) v7(87.16,56.3) v7(87.16,47.5) v7(87.38,37.48) v7(87.43,37.16) v7(87.38,36.79) v7(87.43,36.36) v7(87.43,35.56) v7(87.43,33.16) v7(87.82,52.32) v7(87.82,46.86) v7(87.83,41.96) v7(88.11,41.51) v7(88.45,50.7) v7(88.45,47.5) v7(88.64,41.56) v7(89.75,47.51) v7(89.75,56.3) v7(89.75,53.1) v7(90.4,55.5) v7(90.4,53.89) v7(90.4,49.89) v7(90.64,42.36) v7(91.05,56.3) v7(91.05,53.1) v7(91.05,50.7) v7(92.35,54.7) v7(92.35,53.1) v7(92.35,50.7) v7(93.06,55.39) v7(106,38.85) v7(109.28,36.05) v7(109.6,36) v8(80,50.7) v8(80.64,39.56) v8(80.65,55.5) v8(81.03,39.56) v8(81.03,37.56) v8(81.03,37.16) v8(81.31,47.49) v8(81.43,39.59) v8(81.43,39.16) v8(81.43,38.36) v8(81.43,37.96) v8(81.43,37.56) v8(81.43,37.16) v8(81.83,39.56) v8(81.83,39.16) v8(81.83,38.36) v8(81.83,37.96) v8(81.83,37.56) v8(81.83,37.16) v8(82.24,39.56) v8(82.24,39.16) v8(82.24,38.76) v8(82.24,38.36) v8(82.24,37.96) v8(82.24,37.16) v8(82.61,50.7) v8(82.58,39.99) v8(83.09,39.92) v8(83.49,40.3) v8(83.47,39.95) v8(83.57,36.28) v8(83.83,39.96) v8(83.83,39.16) v8(84.01,40.68) v8(84.24,40.76) v8(84.24,40.36) v8(84.24,39.56) v8(84.24,38.76) v8(84.24,37.96) v8(84.24,36.36) v8(84.82,34.56) v8(85.03,37.16) v8(85.03,36.76) v8(85.03,35.96) v8(85.03,35.56) v8(85.03,35.16) v8(85.03,34.76) v8(85.15,34.13) v8(85.43,40.76) v8(85.44,39.41) v8(85.43,39.16) v8(85.43,38.36) v8(85.43,37.56) v8(85.43,36.76) v8(85.53,39.64) v8(85.56,36.56) v8(85.61,36.33) v8(85.65,40.64) v8(85.66,38.48) v8(85.68,37.4) v8(85.83,40.36) v8(85.84,39.91) v8(85.83,39.56) v8(85.83,38.76) v8(85.76,38.27) v8(85.83,37.96) v8(85.75,37.63) v8(85.81,37.17) v8(85.86,40.76) v8(85.88,38.47) v8(85.91,37.45) v8(86.42,40.73) v8(86.44,34.73) v8(86.51,53.89) v8(86.71,40.77) v8(86.67,34.73) v8(86.9,34.73) v8(87.03,37.56) v8(87,37.2) v8(87.03,36.76) v8(87.03,36.37) v8(87.03,35.96) v8(87,35.55) v8(87.03,35.16) v8(87.18,37.02) v8(87.23,35.4) v8(87.31,40.63) v8(87.25,36.57) v8(87.43,37.16) v8(87.38,36.79) v8(87.43,36.36) v8(87.38,35.83) v8(87.43,35.56) v8(87.41,35.23) v8(87.41,34.95) v8(87.83,41.96) v8(87.79,41.54) v8(88.11,41.51) v8(88.45,47.5) v8(89.75,47.51) v8(89.75,53.1) v8(90.4,53.89) v8(92.35,54.7) v8(92.35,53.1) v8(106,38.85) v8(109.28,36.05) v8(109.6,36) v9(81.33,43.84) v9(81.34,43.16) v9(82.12,35.42) v9(82.12,35.04) v9(82.32,35.83) v9(82.34,35.58) v9(82.36,35.3) v9(82.36,35.05) v9(82.54,35.96) v9(82.54,35.72) v9(82.58,36.41) v9(82.58,36.18) v9(82.56,35.49) v9(82.57,35.21) v9(82.6,34.97) v9(84.18,36.69) v9(84.26,36.44) v9(84.43,41.11) v9(84.41,36.82) v9(84.64,36.87) v9(84.74,37.07) v9(84.87,36.74) v9(84.97,36.41) v9(85.73,37.17) v9(85.76,40.74) v9(86,40.73) v9(87.08,41.06) v9(87.11,40.65) v9(87.42,40.65) v9(87.45,40.27) v9(87.41,39.56) v10(81.33,43.84) v10(81.34,43.16) v10(82.12,35.42) v10(82.12,35.04) v10(82.32,35.83) v10(82.34,35.58) v10(82.36,35.3) v10(82.36,35.05) v10(82.54,35.96) v10(82.54,35.72) v10(82.58,36.41) v10(82.58,36.18) v10(82.56,35.49) v10(82.57,35.21) v10(82.6,34.97) v10(84.18,36.69) v10(84.26,36.44) v10(84.43,41.11) v10(84.41,36.82) v10(84.64,36.87) v10(84.74,37.07) v10(84.87,36.74) v10(84.97,36.41) v10(85.73,37.17) v10(85.76,40.74) v10(86,40.73) v10(87.08,41.06) v10(87.11,40.65) v10(87.42,40.65) v10(87.45,40.27) v10(87.41,39.56)
