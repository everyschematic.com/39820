# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_I2C2_1V8_SENSOR_SDA: length 47.6
  TOP w0.089: R91220.1 147.91,34.14 147.97,34.2 R90514.2 148.8,34.2 148.82,34.18 v2(149.28,34.18)
  IN2 w0.058: v2(149.28,34.18) 149.21,34.25 149.21,37.37 v2(149.83,37.99) 149.46,38.36 149.46,38.61 v3(149.72,38.87)
  IN3 w0.102: v3(129.62,58.79) 129.62,58.65 129.83,58.45 131.98,58.45 132.97,57.46 133.86,57.46 134.88,56.44 134.88,54.34 135.76,53.46 135.76,47.96 135.85,47.87 135.85,45.14 136.48,44.51 138.52,44.51 141.22,41.8 143.33,41.8 144.59,40.54 146.69,40.54 148.72,38.52 149.37,38.52 v3(149.72,38.87)
  IN4 w0.058: v5(128.7,63.53) 128.7,63.36 128.29,62.95 128.29,59.98 128.7,59.57 129.27,59.57 129.52,59.32 129.52,58.9 v3(129.62,58.79)
EC_I2C2_3V3_SCL: length 45.6
  TOP w0.089: Q757.3 R91296.1 143.29,22.33 143.09,22.54 R91051.2 142.83,22.97 142.6,23.19 142.23,23.19 141.74,23.68 140.11,23.68 v2(139.35,22.92) 139.78,22.49 R91203.2 ; U6.22 v2(124.1,35.07)
  IN2 w0.058: v2(139.35,22.92) 139.35,35.43 136.81,37.98 133.76,37.98 131.35,40.39 131.35,40.59 130.11,41.83 125.84,41.83 124.11,40.11 124.11,38.92 123.95,38.75 123.95,38.1 124.29,37.76 124.29,35.27 v2(124.1,35.07)
EC_I2C2_3V3_SDA: length 47.5
  TOP w0.089: v2(124.57,35.08) 124.5,35.01 U6.21 ; R91297.1 144.84,26.88 144.45,26.49 Q759.3 142.93,26.49 142.7,26.27 R91052.2 142.7,25.66 142.43,25.38 141.02,25.38 140.44,24.81 140.44,24.52 v2(138.84,22.92) 138.19,22.26 R91202.2
  IN2 w0.058: v2(138.84,22.92) 139.12,23.2 139.12,35.34 136.71,37.75 133.66,37.75 131.12,40.29 131.12,40.49 130.01,41.61 125.94,41.61 124.34,40.01 124.34,38.84 124.16,38.66 124.16,38.21 124.52,37.85 124.52,35.13 v2(124.57,35.08)
EC_I2C_USB_C0_MUX_SCL: length 2.9
  TOP w0.089: U93.8 18.07,31.7 16.95,32.82 16.95,32.98 17.03,33.06 R91293.2
EC_I2C_USB_C0_MUX_SCL_R: length 8.6
  TOP w0.089: v2(17.25,34.07) R91293.1
  IN2 w0.058: v2(17.25,34.07) 16.95,33.77 16.95,33.38 17.04,33.29 18.11,33.29 18.42,33.6 18.42,33.77 19.25,34.61 19.25,35.86 19.78,36.39 20.26,36.39 20.33,36.46 v3(20.33,37.6)
  IN4 w0.058: v5(20.87,37.6) v3(20.33,37.6)
EC_I2C_USB_C0_MUX_SDA: length 2.9
  TOP w0.089: U93.9 18.2,31.32 16.77,32.75 16.77,33 16.72,33.06 R91294.2
EC_I2C_USB_C0_MUX_SDA_R: length 8.9
  TOP w0.089: v2(16.49,34.07) R91294.1
  IN2 w0.058: v2(16.49,34.07) 16.74,33.82 16.74,33.29 16.95,33.08 18.19,33.08 18.63,33.51 18.63,33.69 19.46,34.52 19.46,35.77 19.87,36.18 20.33,36.18 20.4,36.11 v3(20.4,35.07)
  IN4 w0.058: v5(20.87,35.31) 20.79,35.31 20.54,35.07 v3(20.4,35.07)
EC_IN_RW_OD: length 64.4
  TOP w0.089: U124.A9 53.36,19.29 52.51,19.29 v2(52.08,19.72)
  IN2 w0.058: v8(83.03,35.96) 83.03,35.56 82.51,35.03 82.51,33.49 82.25,33.23 81.44,33.23 v3(81.09,32.87) 80.81,33.15 75.85,33.15 75.42,33.58 75.42,35.59 73.97,37.05 71.98,37.05 71.24,37.79 67.98,37.79 67.51,38.26 66.67,38.26 66.19,37.77 66.19,35.31 65.85,34.97 60.86,34.97 59.05,36.79 56.99,36.79 56.93,36.84 v3(56.93,36.86) ; v2(52.08,19.72) 51.8,19.72 v3(51.62,19.54)
  IN4 w0.058: v4(57.22,36.7) 57.06,36.86 v3(56.93,36.86) ; v5(82.36,32.77) 81.19,32.77 v3(81.09,32.87) ; v3(51.62,19.54) v4(51.29,19.54)
  IN5 w0.076: v4(51.29,19.54) 51.18,19.66 51.18,25.21 53.18,27.21 58.1,27.21 59.77,28.89 59.77,33.77 57.22,36.32 v4(57.22,36.7)
EC_KSI: length 7.3
  TOP w0.089: v2(53.07,18.91) U124.A8
  IN2 w0.058: v3(52.74,18.75) 52.92,18.75 v2(53.07,18.91)
  IN4 w0.058: v4(52.17,18.43) 52.49,18.75 v3(52.74,18.75)
  IN5 w0.076: v5(51.19,13.96) 51.19,14.13 52.17,15.11 v4(52.17,18.43)
  BOTTOM w0.089: R3004.1 51.19,13.48 v5(51.19,13.96)
EC_KSI2: length 111.7
  TOP w0.089: U6559.23 v2(144.59,17.68)
  IN2 w0.058: v2(144.59,17.68) 144.92,17.34 144.92,16.21 143.3,14.59 138.77,14.59 137.08,12.9 136.28,12.9 134.96,11.57 131.09,11.57 130.35,10.84 130.24,10.84 130.05,10.65 129.65,10.65 129.4,10.4 128.17,10.4 127.97,10.2 126.16,10.2 125.61,9.66 125.61,9.16 125.34,8.89 125.34,8.06 125.1,7.82 123.94,7.82 123.54,7.42 121.48,7.42 120.77,6.71 91.31,6.71 88.33,9.69 85.87,9.69 84.86,10.7 81.6,10.7 80.4,10.24 79.37,9.8 75.29,5.72 74.83,5.72 72.75,3.64 68.52,3.64 68,3.12 65.71,3.12 60.55,8.27 60.55,8.44 60.42,8.57 v3(60.42,8.81)
  IN4 w0.058: v4(59.42,10.04) 59.42,9.69 59.57,9.54 59.84,9.54 60.42,8.95 v3(60.42,8.81)
  IN5 w0.076: v5(52.21,13.57) 52.13,13.49 52.13,12.22 52.79,11.56 54.76,11.56 55.6,10.72 58.73,10.72 v4(59.42,10.04)
  BOTTOM w0.089: v5(52.21,13.57) 52.21,13.85 52.09,13.96 R3006.2 51.81,13.96 51.36,14.41 R3003.2
EC_KSI3: length 107.3
  TOP w0.089: U6559.19 144.33,16.08 v2(144.61,16.36)
  IN2 w0.058: v2(144.61,16.36) 143.05,14.8 138.68,14.8 136.99,13.11 136.2,13.11 134.87,11.78 131,11.78 130.27,11.05 130.15,11.05 129.96,10.86 129.56,10.86 129.32,10.61 128.08,10.61 127.88,10.42 126.07,10.42 125.4,9.74 125.4,9.25 124.8,8.64 122.4,8.64 120.68,6.92 91.4,6.92 88.42,9.9 85.96,9.9 84.95,10.91 81.56,10.91 80.32,10.43 79.25,9.97 75.37,6.1 73.99,6.1 72.51,4.62 69.1,4.62 67.8,3.33 65.79,3.33 60.98,8.14 v3(60.98,8.53)
  IN4 w0.058: v4(59.8,9.89) 60.1,9.58 60.2,9.58 60.98,8.8 v3(60.98,8.53)
  IN5 w0.076: v5(52.52,12.34) 53.07,11.79 54.86,11.79 55.7,10.95 58.99,10.95 59.8,10.14 v4(59.8,9.89)
  BOTTOM w0.089: v5(52.52,12.34) 52.21,12.65 R3005.2 R3004.2
EC_KSO2_INV: length 107
  TOP w0.089: U6559.47 136.99,14.08 136.76,13.85 v2(136.76,13.6)
  IN2 w0.058: v3(58.43,8.57) 58.43,8.94 58.9,9.4 60.41,9.4 60.61,9.2 60.87,9.2 61.3,8.78 61.91,8.78 62.02,8.66 62.02,7.7 65.98,3.75 67.63,3.75 69.12,5.24 69.12,5.85 69.22,5.95 69.75,5.95 70.53,6.73 75.11,6.73 78.88,10.51 80.08,11.02 81.45,11.54 85.21,11.54 86.22,10.53 88.68,10.53 91.66,7.55 120.41,7.55 124.58,11.72 127.35,11.72 127.66,12.03 128.71,12.03 129.23,12.55 132.55,12.55 132.92,12.18 133.86,12.18 134,12.32 135.04,12.32 136.32,13.6 v2(136.76,13.6) ; v2(51.19,18.17) v3(51.19,17.84)
  IN4 w0.058: v3(51.19,17.84) v4(51.52,17.84) ; v3(58.43,8.57) 58.43,8.74 v4(57.64,9.53)
  IN5 w0.076: v4(57.64,9.53) 57.51,9.53 57.39,9.66 55.28,9.66 54.32,10.62 52.44,10.62 51.21,11.84 51.21,12.84 50.3,13.75 50.3,14.89 50.83,15.42 50.83,17.02 51.52,17.71 v4(51.52,17.84)
EC_NRST: length 15.9
  TOP w0.089: v2(122.37,46.04) 122.33,46.01 122.33,43.9 122.95,43.28 Q739.4 ; U6517.E1 128.79,50.42 C10425.1 129.17,49.93 129.08,49.84 128.68,49.84 v2(128.44,50.08)
  IN2 w0.058: v2(128.44,50.08) 128.47,50.06 128.47,48.47 128.28,48.28 128.28,47.22 127.87,46.82 126.52,46.82 126.12,46.41 124.72,46.41 124.42,46.72 123.04,46.72 v2(122.37,46.04)
EC_PMIC_WATCHDOG_L: length 47.1
  TOP w0.089: v2(104.5,51.78) 103.89,51.17 100.61,51.17 99.93,50.48 99.93,48.5 100.51,47.92 101.2,47.92 101.36,47.75 R90453.2
  IN1 w0.076: v2(105.47,46.9) v2(105.47,47.54)
  IN2 w0.058: v8(106.02,40.05) 106,40.08 106,40.73 106.27,41 106.4,41 106.66,41.26 106.66,42.21 105.75,43.12 105.75,44.2 105.37,44.58 105.37,46.79 v2(105.47,46.9) ; v2(126.34,50.92) 126.09,50.68 123.55,50.68 122.89,51.34 122.58,51.34 122.37,51.55 119.63,51.55 118.42,52.76 v3(114.51,52.76) ; v2(105.47,47.54) 104.67,47.54 104.05,48.16 104.05,48.83 103.89,48.98 103.89,51.18 v2(104.5,51.78) 104.55,51.73 v3(105.82,51.73)
  IN3 w0.102: v3(114.51,52.76) 114.18,52.76 113.31,53.63 111.68,53.63 109.93,51.88 105.97,51.88 v3(105.82,51.73)
EC_PROCHOT_ODL: length 17.4
  TOP w0.089: v2(122.13,36.68) 122.44,36.68 122.7,36.42 R91191.1
  IN1 w0.076: v1(129.14,46.36) 127.11,46.36 126.86,46.11 126.86,45.09 126.6,44.84 123.14,44.84 122.78,44.47 122.78,43.2 121.87,42.3 v2(121.65,42.3)
  IN2 w0.058: v2(121.65,42.3) 122.41,41.54 122.41,36.96 v2(122.13,36.68)
EC_PWR_BTN_ODL: length 137.9
  TOP w0.089: R90460.2 128.63,52.72 128.14,52.23 127.16,52.23 127.08,52.15 127.08,51.67 U6517.G2
  IN1 w0.076: v2(134.48,37.42) 132.11,39.78 132.11,41.41 131.68,41.84 131.68,45.73 132.11,46.16 132.11,48.26 131.1,49.28 131.1,51.19 128.63,53.65 v1(128.63,53.73)
  IN2 w0.058: v3(54.49,16.87) 54.31,17.05 54.31,18.01 53.98,18.34 v2(53.98,18.41) ; v3(134.04,37.27) 134.2,37.42 v2(134.48,37.42)
  IN3 w0.102: v3(134.04,37.27) 134.04,36.76 132.55,35.26 123.32,35.26 121.52,33.46 121.52,28.53 122.11,27.94 122.11,27.77 122.11,27.77 122.11,26.33 122.11,26.33 122.11,21.09 124.14,19.06 124.14,14.94 122.57,13.37 120.89,13.37 117.69,10.17 117.69,9.91 117.13,9.34 116.39,9.34 114.59,7.54 91.26,7.54 89.02,9.77 87.01,9.77 85.84,10.94 70.36,10.94 69.37,9.94 64.7,9.94 63.72,10.93 62.61,10.93 61.86,11.68 61.86,12.78 61.07,13.57 61.07,14.84 60.66,15.25 59.57,15.25 58.12,16.69 54.67,16.69 v3(54.49,16.87)
EC_RST_ODL: length 213.1
  TOP w0.203: v1(43.67,36.71) 43.67,36.33 41.94,34.6 v1(35.67,34.6)
  TOP w0.508: v6(48.27,12.81) 48.9,12.81 49.26,13.16 50.47,13.16 R90630.2
  IN1 w0.203: v2(35.67,34.3) v1(35.67,34.6) ; v2(60.96,34.44) 60.77,34.63 59.95,34.63 59.85,34.73 58.1,34.73 56.97,35.86 55.77,35.86 55.18,36.46 55.18,36.68 51.6,40.27 51.16,40.27 48.22,43.21 47,43.21 44.94,41.15 44.94,41 43.67,39.73 v1(43.67,36.71)
  IN2 w0.058: v3(123.7,43.54) v2(123.7,43.89)
  IN2 w0.203: v2(60.96,34.44) 62.12,34.44 v3(62.21,34.35) ; v3(35.67,34.68) v2(35.67,34.3)
  IN2 w0.254: v2(40.65,6.61) v3(40.32,6.61) ; v3(51.19,16.06) v2(51.19,16.39)
  IN2 w0.381: v6(48.27,12.81) 48.27,12.4 47.91,12.05 v3(47.91,7.88)
  IN3 w0.102: v3(123.7,43.54) 123.7,40.89 122.84,40.04 122.84,35.21 121.22,33.58 121.22,28.4 121.8,27.82 121.8,27.64 121.81,27.64 121.81,26.46 121.8,26.46 121.8,20.96 123.83,18.93 123.83,15.07 122.44,13.67 120.4,13.67 118.01,11.28 117.1,11.28 116.09,10.26 116.09,9.47 114.46,7.84 91.38,7.84 89.15,10.08 87.14,10.08 85.97,11.24 70.23,11.24 69.26,10.27 64.81,10.27 63.84,11.23 62.74,11.23 62.16,11.81 62.16,12.91 61.37,13.7 61.37,14.96 60.79,15.55 59.69,15.55 57.13,18.12 55.04,18.12 54.02,17.1 54.02,16.43 53.66,16.06 v3(51.19,16.06)
  IN3 w0.203: v3(35.67,34.68) 35.67,33.81 37.7,31.78 37.7,27.31 39.48,25.53 40.24,25.53 42.73,23.04 42.73,20.43 43.14,20.02 43.14,16.29 43.49,15.93 51.06,15.93 v3(51.19,16.06)
  IN3 w0.381: v3(40.32,6.61) 40.63,6.91 45.8,6.91 46.77,7.88 v3(47.91,7.88)
  IN4 w0.203: v3(62.21,34.35) v4(62.21,34.93)
  IN4 w0.254: v5(51.82,16.06) v3(51.19,16.06)
  IN5 w0.203: v5(69.48,40.17) 67.42,38.11 67.42,35.44 67.14,35.16 62.44,35.16 v4(62.21,34.93)
  BOTTOM w0.203: R91319.2 v5(69.48,40.17)
  BOTTOM w0.508: R90682.2 47.81,13.26 v6(48.27,12.81)
  vias: v4(51.42,15.63) v4(51.42,15.37) v4(51.67,15.63) v4(51.67,15.37) v5(51.42,15.63) v5(51.42,15.37) v5(51.67,15.63) v5(51.67,15.37)
EC_RST_ODL_Q: length 1.5
  TOP w0.089: Q739.6 123.65,43.34 123.53,43.47 123.12,43.47 122.95,43.63 Q739.3
EC_RST_ODL_R: length 1.1
  BOTTOM w0.089: R90967.2 48.58,18.57 U6548.3
EC_RST_R_L: length 1.2
  BOTTOM w0.203: R91319.1 70.47,40.9 70.46,40.91 U6581.3
EC_SENSOR_SPI_CK: length 41.9
  TOP w0.089: R91222.1 146.79,32.28 146.88,32.19 148.14,32.19 v2(148.19,32.14)
  IN2 w0.058: v2(124.34,51.42) 125.12,52.2 127.24,52.2 v3(127.49,52.46) ; v2(148.19,32.14) v3(148.57,32.14)
  IN3 w0.102: v3(127.49,52.46) 128.18,51.77 128.18,45.09 130.21,43.06 130.47,43.06 133.97,39.55 141.03,39.55 142.81,37.78 144.93,37.78 146.73,35.97 148.29,35.97 149.44,34.83 149.44,33 v3(148.57,32.14)
EC_SENSOR_SPI_MISO: length 28.9
  TOP w0.089: R91224.1 144.38,36.07 144.1,36.35 142.12,36.35 137.96,40.52 v1(131.33,40.52)
  IN1 w0.076: v1(131.33,40.52) 130.77,41.08 130.77,46.28 131.2,46.71 131.2,47.89 130.91,48.17 129.28,48.17 128.48,48.97 128.48,49.25 126.84,50.9 v1(126.84,50.92)
EC_SENSOR_SPI_MOSI: length 33.2
  TOP w0.089: v1(127.74,51.31) 127.64,51.42 U6517.G1 ; v1(131.33,40.98) 137.88,40.98 142.12,36.73 146.39,36.73 146.79,36.33 R91221.1
  IN1 w0.076: v1(131.33,40.98) 131,41.31 131,46.18 131.43,46.62 131.43,47.98 131.01,48.4 129.38,48.4 128.71,49.07 128.71,49.34 127.74,50.31 v1(127.74,51.31)
EC_SENSOR_SPI_NSS: length 44.2
  TOP w0.089: v1(140.65,30.02) 140.65,29.9 140.95,29.6 142.35,29.6 142.86,29.09 145.17,29.09 147.07,30.99 147.43,30.99 147.56,31.12 R91223.1
  IN1 w0.076: v1(123.84,51.92) 123.99,52.08 125.84,52.08 126.07,52.3 127.53,52.3 128.38,51.46 128.38,50.93 129.17,50.15 129.17,49.26 129.56,48.86 131.19,48.86 131.89,48.17 131.89,46.31 131.45,45.88 131.45,41.71 131.89,41.28 131.89,39.68 133.04,38.53 133.04,37.97 134.04,36.96 138.79,36.96 140.65,35.11 v1(140.65,30.02)
EC_SKU_ID: length 5.5
  TOP w0.089: R90982.2 123.11,53.73 R90983.1 123.3,53.53 v1(123.3,52.46)
  IN1 w0.076: v1(123.3,52.46) 123.52,52.24 123.52,51.78 123.73,51.57 123.93,51.57 124.19,51.82 124.57,51.82 125.34,51.05 v1(125.34,50.92)
EC_SLG_SYS_RST_L: length 200.2
  TOP w0.089: U6517.B6 125.08,48.68 125.08,48.11 124.19,47.22 R91142.2 124.37,46.84 124.67,46.54 124.67,45.32 124.82,45.17 124.82,43.03 v2(124.93,42.93) ; R90582.1 104.88,25.26 v1(105.52,24.62)
  IN1 w0.076: v2(115.36,27.73) 115.36,27.3 115.77,26.9 115.77,25.64 115.27,25.15 113.04,25.15 112.58,25.61 108.34,25.61 107.96,25.23 106.54,25.23 105.93,24.62 v1(105.52,24.62)
  IN2 w0.058: v3(67.37,44.18) 66.91,44.63 66.48,44.63 66.09,44.24 65.61,44.24 65.24,43.87 64.65,43.87 64.42,43.64 64.42,43.62 63.08,42.27 63.08,42.02 62.37,41.31 61.98,41.31 61.82,41.14 61.82,40.39 60.72,39.29 56.28,39.29 55.35,40.21 54.31,40.21 51.6,37.5 42.73,37.5 42.43,37.19 40.37,37.19 40.19,37.01 38.79,37.01 38.49,36.71 38.49,36.07 37.93,35.52 37.42,35.52 37.14,35.24 37.14,33.79 v3(37.24,33.69) ; v2(115.36,27.73) 115.64,28.01 117.16,28.01 117.49,27.68 118.12,27.68 118.45,27.35 119.75,27.35 120.13,27.73 120.13,31.97 120.41,32.25 120.41,33.01 121.45,34.06 121.45,34.44 122.9,35.88 122.9,40.9 v2(124.93,42.93) 124.95,42.96 v3(127.47,42.96)
  IN3 w0.102: v3(45.78,17.89) 44.64,17.89 43.49,19.03 43.49,20.17 43.09,20.58 43.09,23.45 40.5,26.04 39.61,26.04 38.08,27.57 38.08,32.85 v3(37.24,33.69) ; v3(67.37,44.18) 66.71,44.83 66.71,48.62 67.61,49.51 68.77,49.51 69.67,50.41 69.67,53.16 70.29,53.78 70.29,58.26 71.67,59.65 72.79,59.65 77.24,64.09 115.81,64.09 119.26,60.64 119.26,59.07 120.66,57.67 120.66,56.23 122.58,54.31 123.27,54.31 123.68,53.9 123.68,50.56 124.83,49.41 125.82,49.41 126.63,48.6 126.63,46.95 127.26,46.31 127.26,43.16 v3(127.47,42.96)
  IN4 w0.058: v3(45.78,17.89) v5(46.13,17.89)
  BOTTOM w0.089: v5(46.13,17.89) 46.82,17.89 47.1,18.17 R90966.1
EC_SLG_SYS_RST_L_R: length 1
  BOTTOM w0.089: U6548.2 R90966.2
EC_UART_VREF: length 4.3
  BOTTOM w0.203: CON16.34 41.3,8.94 41.33,8.96 41.33,10.64 41.61,10.93 C414.1 41.61,12.09 R90440.1
EDP_AUX_C_N: length 27.7
  IN2 w0.069: v2(60.57,39.88) 60.39,40.06 59.86,40.06 59.45,39.66 58.63,39.66 v3(58.2,40.09)
  IN3 w0.112: v3(58.2,40.09) 58.37,39.92 58.37,39.82 58.19,39.64 57,39.64 56.53,40.11 56.53,41.18 56.96,41.6 56.96,41.97 56.7,42.22 56.27,42.22 55.66,41.61 55.66,39.76 55.94,39.48 55.94,39.05 54.68,37.79 53.79,37.79 53.26,37.26 43.58,37.26 43.37,37.47 43.37,37.62 43.37,37.65 43.37,37.83 43.47,37.93 v3(43.67,37.93)
  IN4 w0.069: v5(43.67,37.6) v3(43.67,37.93)
  BOTTOM w0.091: J15.20 43.55,36.83 43.4,36.98 43.4,37.42 43.59,37.6 v5(43.67,37.6)
EDP_AUX_C_P: length 27.8
  IN2 w0.069: v3(58.81,40.09) 58.81,39.99 58.91,39.89 59.36,39.89 59.76,40.3 60.47,40.3 v2(60.6,40.42)
  IN3 w0.112: v3(42.91,37.93) 43.1,37.73 43.1,37.65 43.1,37.62 43.1,37.36 43.47,36.99 53.37,36.99 53.9,37.52 54.79,37.52 56.21,38.94 56.21,39.59 55.92,39.87 55.92,41.5 56.38,41.96 56.59,41.96 56.69,41.86 56.69,41.71 56.27,41.29 56.27,40 56.89,39.38 58.3,39.38 58.63,39.71 58.63,39.91 v3(58.81,40.09)
  IN4 w0.069: v5(42.91,37.6) v3(42.91,37.93)
  BOTTOM w0.091: J15.19 43.05,36.85 43.16,36.96 43.16,37.47 43.04,37.6 v5(42.91,37.6)
EDP_AUX_N: length 4.6
  TOP w0.091: C229.2 61.09,39.81 62.26,39.81 62.56,40.1 62.56,40.35 62.73,40.53 63.04,40.53 v1(63.18,40.39)
  IN1 w0.058: v1(63.18,40.39) 63.27,40.49 63.91,40.49 64.37,40.95 64.37,41.34 v1(64.46,41.42)
EDP_AUX_P: length 4.6
  TOP w0.091: C228.2 61.04,40.34 61.29,40.1 61.62,40.1 TP9179.1 62,40.05 62.16,40.05 62.31,40.2 62.31,40.45 62.63,40.77 63.13,40.77 v1(63.18,40.82)
  IN1 w0.058: v1(63.18,40.82) 63.31,40.7 63.82,40.7 64.16,41.04 64.16,41.32 v1(64.06,41.42)
EDP_BL_VOUT:
  vias: v6(47.96,41.66) v6(48.34,42.3) v6(48.52,37.98) v6(48.67,41.66) v6(49.23,37.98) v6(49.94,37.95)
EDP_HPD: length 11.3
  TOP w0.089: Q792.2 51.73,37.67 R91242.2 51.65,37.93 v2(51.44,38.13)
  IN2 w0.058: v2(51.44,38.13) 51.24,37.92 v3(50.63,37.92)
  IN4 w0.058: v5(50.99,37.92) v3(50.63,37.92)
  BOTTOM w0.089: J15.22 44.55,37.92 44.81,38.18 45.98,38.18 46.24,38.44 50.48,38.44 v5(50.99,37.92)
EDP_TX0_C_N: length 29.8
  IN2 w0.069: v2(60.59,41.92) 60.87,41.92 v3(60.97,41.81)
  IN3 w0.112: v3(41.38,34.78) 41.6,35 41.6,35.45 42.08,35.93 46.64,35.93 46.96,35.6 46.96,35.44 47.04,35.36 47.37,35.36 47.47,35.47 47.47,35.63 47.72,35.88 48.39,35.88 48.64,35.63 48.64,35.29 48.72,35.21 49.05,35.21 49.12,35.29 49.12,35.67 49.36,35.91 49.94,35.91 50.16,35.68 50.16,35.26 50.24,35.19 50.57,35.19 50.67,35.29 50.67,35.67 50.92,35.92 51.46,35.92 51.76,35.63 51.76,35.28 51.84,35.2 51.98,35.2 52.68,35.9 55.62,35.9 55.88,36.16 55.88,37.11 57.08,38.31 59.24,38.31 60.24,39.31 60.24,41.29 60.56,41.61 60.77,41.61 v3(60.97,41.81)
  IN4 w0.069: v5(41.38,35.11) v3(41.38,34.78)
  BOTTOM w0.091: v5(41.38,35.11) 41.55,35.27 J15.16
EDP_TX0_C_P: length 29.8
  IN2 w0.069: v2(60.59,41.2) v3(60.99,41.2)
  IN3 w0.112: v3(60.99,41.2) 60.85,41.35 60.67,41.35 60.51,41.18 60.51,39.2 59.35,38.05 57.19,38.05 56.15,37 56.15,36.05 55.73,35.64 52.79,35.64 52.09,34.93 51.73,34.93 51.49,35.17 51.49,35.52 51.35,35.66 51.03,35.66 50.94,35.56 50.94,35.18 50.68,34.92 50.13,34.92 50.01,35.04 49.9,35.15 49.9,35.57 49.83,35.64 49.47,35.64 49.39,35.56 49.39,35.18 49.16,34.95 48.61,34.95 48.38,35.18 48.38,35.52 48.28,35.62 47.83,35.62 47.74,35.52 47.74,35.36 47.48,35.1 46.93,35.1 46.7,35.33 46.7,35.49 46.53,35.66 42.19,35.66 41.87,35.34 41.87,34.88 41.97,34.78 v3(42.25,34.78)
  IN4 w0.069: v5(42.15,35.11) 42.15,34.88 v3(42.25,34.78)
  BOTTOM w0.091: J15.17 42.05,35.49 41.92,35.36 41.92,35.19 41.99,35.11 v5(42.15,35.11)
EDP_TX0_N: length 2.8
  TOP w0.091: C527.2 61.31,41.65 62.72,41.65 62.84,41.76 63.6,41.76 U6578.A3
EDP_TX0_P: length 2.8
  TOP w0.091: C526.2 61.24,41.41 62.82,41.41 62.94,41.52 63.56,41.52 U6578.A2
EDP_TX1_C_N: length 31.2
  IN2 w0.069: v2(60.59,43.34) 60.36,43.11 v3(60.26,43.11)
  IN3 w0.112: v3(60.26,43.11) 60.06,42.92 59.76,42.92 59.49,42.65 59.49,39.74 58.74,38.99 56.8,38.99 54.4,36.59 42.49,36.59 41.72,37.37 35.53,37.37 35.2,37.04 35.2,36.74 v3(35.05,36.58)
  IN4 w0.069: v5(35.05,36.25) v3(35.05,36.58)
EDP_TX1_C_P: length 31.2
  IN2 w0.069: v3(60.23,42.47) 60.23,42.58 60.35,42.7 60.54,42.7 v2(60.59,42.65)
  IN3 w0.112: v3(35.73,36.61) 35.65,36.61 35.47,36.79 35.47,36.93 35.64,37.1 41.61,37.1 42.38,36.33 54.51,36.33 56.91,38.73 58.85,38.73 59.75,39.63 59.75,42.54 59.87,42.65 60.15,42.65 60.23,42.57 v3(60.23,42.47)
  IN4 w0.069: v5(35.55,36.25) 35.49,36.31 35.49,36.56 35.54,36.61 v3(35.73,36.61)
EDP_TX1_N: length 3.4
  TOP w0.091: v1(63.13,43.03) 63.04,42.94 62.8,42.94 62.74,42.88 61.82,42.88 61.55,43.15 61.26,43.15 C10509.2
  IN1 w0.058: v1(64.06,43.02) 63.97,42.94 63.22,42.94 v1(63.13,43.03)
EDP_TX1_P: length 3.4
  TOP w0.091: v1(63.13,42.63) 63.05,42.7 62.9,42.7 62.84,42.64 61.72,42.64 61.45,42.91 61.3,42.91 C10510.2
  IN1 w0.058: v1(64.06,42.62) 63.95,42.73 63.23,42.73 v1(63.13,42.63)
EEPROM_WP_OD: length 1.5
  TOP w0.089: Q750.3 121.06,58.38 121.47,58.78 U6547.7
EMI0_CA0: length 7.1
  TOP w0.06: UD1.H2 83.25,48.55 v8(83.15,48.65)
  IN2 w0.06: v8(83.83,42.36) 83.83,42.36 83.64,42.56 83.64,42.92 83.66,42.94 83.66,47.38 83.58,47.46 83.48,47.46 83.03,47.91 83.03,48.54 v8(83.15,48.65)
EMI0_CA1: length 7.1
  TOP w0.06: UD1.J2 83.55,47.94 82.55,47.94 v8(82.28,47.68) ; v8(82.62,45.91) 82.8,45.91 83.02,45.69 83.02,44.42 83.29,44.15 83.29,43.41 U1001.C7
  IN2 w0.06: v8(82.62,45.91) 82.24,46.29 82.24,47.63 82.27,47.66 v8(82.28,47.68)
EMI0_CA2: length 19
  TOP w0.06: U1001.B5 82.46,43.79 82.46,44.07 82.39,44.14 82.39,45.06 81.73,45.72 80.56,45.72 80.45,45.6 78.38,45.6 v8(78.37,45.58) ; v8(82.9,52.05) 82.9,53.54 UD1.H9
  IN2 w0.06: v8(78.37,45.58) 77.73,46.21 77.73,50.63 78.77,51.67 82.51,51.67 v8(82.9,52.05)
EMI0_CA3: length 25.6
  TOP w0.06: U1001.B6 82.64,44.12 82.55,44.21 82.55,45.21 81.89,45.87 80.46,45.87 80.4,45.81 77.98,45.81 77.03,46.76 77.03,53.5 78.05,54.52 78.05,56.39 78.51,56.84 83.1,56.84 83.57,56.36 83.57,55.02 UD1.H10
EMI0_CA4: length 23.8
  TOP w0.06: U1001.B7 82.8,43.8 82.8,44.19 82.71,44.29 82.71,45.34 82.03,46.02 78.07,46.02 77.24,46.84 77.24,53.41 78.27,54.43 78.27,56.28 78.62,56.63 82.66,56.63 82.93,56.36 82.93,55.82 83.25,55.5 UD1.H11
EMI0_CA5: length 15.5
  TOP w0.06: v8(83.32,52.01) 84,52.01 84.22,52.22 84.22,55.18 83.91,55.49 UD1.J11
  IN2 w0.06: v8(83.32,52.01) 82.3,50.99 82.3,50.41 81.63,49.74 81.63,49.02 81.72,48.92 81.72,46.01 83.02,44.72 83.02,43.04 82.83,42.86 82.83,42.56 v8(83.03,42.36)
EMI0_CK_C: length 12.4
  TOP w0.06: v8(83.59,52.65) 83.55,52.69 83.55,53.5 83.73,53.69 83.85,53.69 83.9,53.74 UD1.J9
  IN2 w0.06: v8(83.59,52.65) 84.1,52.14 84.1,49.68 83.69,49.28 83.69,48.46 83.91,48.25 83.91,47.94 84.1,47.76 84.1,42.92 84.03,42.86 84.03,42.56 v8(84.24,42.36)
EMI0_CK_T: length 12.3
  TOP w0.06: UD1.J8 84.01,53.2 84.01,53.51 83.95,53.57 83.78,53.57 83.67,53.45 83.67,52.86 83.78,52.74 v8(83.91,52.74)
  IN2 w0.06: v8(83.91,52.74) 83.84,52.74 83.81,52.7 83.81,52.6 84.21,52.19 84.21,49.63 83.82,49.23 83.82,48.51 84.03,48.3 84.03,47.99 84.21,47.81 84.21,42.78 v8(84.24,42.76)
EMI0_CKE0: length 9.1
  TOP w0.06: v8(83.59,50.08) 83.73,50.08 83.91,49.9 UD1.J4
  IN2 w0.06: v8(83.59,50.08) 83.49,50.08 83.06,49.64 83.06,49.2 82.73,48.88 82.73,47.71 82.91,47.52 82.91,47 82.64,46.72 82.64,46.27 83.32,45.59 83.32,42.95 83.24,42.87 83.24,42.56 v8(83.43,42.36)
EMI0_CKE1: length 9.9
  TOP w0.06: v8(82.54,50.32) 83.53,50.32 UD1.J5
  IN2 w0.06: v8(83.03,42.76) 83.03,42.86 83.16,42.99 83.16,44.8 81.87,46.09 81.87,48.64 82.32,49.09 82.32,50.1 v8(82.54,50.32)
EMI0_CS0: length 7.8
  TOP w0.06: v8(83.32,49.55) 83.33,49.56 83.33,49.82 UD1.H4
  IN2 w0.06: v8(83.43,42.76) 83.46,42.79 83.46,45.72 82.83,46.35 82.83,46.71 83.1,46.98 83.1,47.55 82.88,47.77 82.88,48.75 83.21,49.08 83.21,49.44 v8(83.32,49.55)
EMI0_CS1: length 6.6
  TOP w0.06: UD1.H3 82.88,48.72 v8(82.52,48.72) ; U1001.A7 83.03,44.19 82.86,44.36 82.86,45.52 82.79,45.6 v8(82.78,45.59)
  IN2 w0.06: v8(82.78,45.59) 82.59,45.59 82.02,46.16 82.02,48.51 82.24,48.72 v8(82.52,48.72)
EMI0_DMI0: length 7.6
  TOP w0.06: 81.72,44.96 81.81,44.87 81.81,43.58 U1001.B4
  TOP w0.089: v8(80.33,48.74) 80.33,48.77 UD1.C3
  TOP w0.12: 81.72,44.96 81.55,45.13 v8(80.83,45.13)
  IN2 w0.075: v8(80.33,48.74) 80.22,48.74 79.32,47.84 79.32,46.82 80.83,45.3 v8(80.83,45.13)
EMI0_DMI1: length 18.3
  TOP w0.06: 83.39,44.69 83.4,44.69 83.43,44.65 U1001.C8
  TOP w0.12: 83.39,44.69 83.29,44.79 83.29,45.79 82.8,46.29 78.19,46.29 77.51,46.96 77.51,53.16 78.65,54.3 79.6,54.3 UD1.C10
EMI0_DQ0: length 7.7
  TOP w0.089: UD1.B2 79.34,48.3 v8(79.06,48.02)
  IN2 w0.06: 82.03,43.37 82.03,42.56 v8(82.23,42.36)
  IN2 w0.075: v8(79.06,48.02) 79.1,47.99 79.1,46.69 80.51,45.28 80.51,45.01 80.68,44.83 81.29,44.83 81.81,44.31 81.81,43.59 82.03,43.37
EMI0_DQ1: length 6.7
  TOP w0.089: v8(80.14,47.88) 80,48.02 UD1.C2
  IN2 w0.06: 82.41,43.72 82.45,43.69 82.45,43.08 82.23,42.87 v8(82.23,42.76)
  IN2 w0.075: 82.41,43.72 82.34,43.79 82.34,44.44 80.22,46.57 80.22,47.32 80.28,47.38 80.28,47.6 80.14,47.74 v8(80.14,47.88)
EMI0_DQ2: length 7
  TOP w0.075: UD1.E2 81.3,48.28 v8(81.05,48.03)
  IN2 w0.06: v8(82.63,42.36) 82.43,42.56 82.43,42.86 82.65,43.08 82.65,43.79 82.57,43.88
  IN2 w0.075: v8(81.05,48.03) 81.05,47.92 80.88,47.76 80.88,46.23 82.57,44.54 82.57,43.88
EMI0_DQ3: length 7.6
  TOP w0.075: UD1.F2 81.59,48.66 v8(81.28,48.66)
  IN2 w0.06: v8(82.63,42.76) 82.63,42.86 82.83,43.06 82.83,43.93 82.8,43.97
  IN2 w0.075: 82.8,43.97 82.8,44.63 81.24,46.18 81.24,46.75 81.08,46.92 81.08,47.63 81.29,47.85 81.29,48.64 v8(81.28,48.66)
EMI0_DQ4: length 13.8
  TOP w0.06: U1001.B3 81.67,43.79 81.67,44.33 81.51,44.48
  TOP w0.075: v8(80.3,50.32) 80.35,50.37 81.48,50.37 UD1.F4
  TOP w0.12: 81.51,44.48 81.23,44.77 79.96,44.77 v8(79.87,44.86)
  IN2 w0.075: v8(80.3,50.32) 78.21,50.32 77.95,50.07 77.95,46.37 78.75,45.58 78.75,45.1 79.13,44.71 79.72,44.71 v8(79.87,44.86)
EMI0_DQ5: length 9.4
  TOP w0.075: UD1.E4 81.14,49.89 v8(80.99,50.05)
  IN2 w0.075: v8(80.99,50.05) 81.03,50 81.03,48.62 80.92,48.51 80.53,48.51 80.36,48.33 80.17,48.33 79.54,47.71 79.54,46.92 82.08,44.39 82.08,43.73 82.24,43.57 U1001.C5 v8(82.23,43.16)
EMI0_DQ6: length 10.2
  TOP w0.06: 82.05,44.65 81.97,44.55 81.97,44.11 82.12,43.96 U1001.A5
  TOP w0.12: v8(79.6,45.28) 80.52,45.28 80.69,45.45 81.61,45.45 82.05,45.01 82.05,44.65
  IN2 w0.075: v8(80,49.89) 79.8,49.89 79.26,49.36 78.66,49.36 78.41,49.1 78.41,46.56 79.6,45.36 v8(79.6,45.28)
EMI0_DQ7: length 8.9
  TOP w0.12: U1001.A3 81.43,44.17 81.11,44.5 79.66,44.5 79.26,44.9 v8(79.26,45.02)
  IN2 w0.075: v8(79.35,49.89) 79.06,49.6 78.58,49.6 78.19,49.2 78.19,46.46 79,45.64 79,45.28 v8(79.26,45.02)
EMI0_DQ8: length 17.6
  TOP w0.06: U1001.B11 84.4,43.8 84.4,44.09 84.48,44.18
  TOP w0.12: 84.48,44.18 84.48,44.5 84.44,44.54 84.44,46.28 84.23,46.49 84.23,50.95 83.97,51.21 82.35,51.21 81.59,51.97 v8(80.87,51.97)
  IN2 w0.075: v8(80.87,51.97) 79.12,51.97 78.36,52.73 78.36,54.76 79.09,55.5 v8(79.35,55.5)
EMI0_DQ9: length 18.9
  IN2 w0.06: v8(84.64,42.36) 84.43,42.56 84.43,42.91
  IN2 w0.075: 84.43,42.91 84.43,46.94 84.76,47.27 84.76,50.04 84.46,50.34 84.46,52.73 83.85,53.35 79.57,53.35 79.35,53.56 79.27,53.56 79.05,53.78 79.05,54.86 79.34,55.15 79.66,55.15 v8(80,55.5)
EMI0_DQ10: length 18.8
  TOP w0.06: 84.21,44.28 84.24,44.26 U1001.B10
  TOP w0.12: UD1.E11 80.98,55.17 80.98,52.84 80.22,52.09 79.28,52.09 78.38,51.19 78.38,47.38 78.57,47.19 83.11,47.19 83.88,46.41 84.21,46.08 84.21,44.28
EMI0_DQ11: length 20.2
  TOP w0.12: UD1.F11 81.95,55.5 81.58,55.87 80.55,55.87 80.33,55.65 80.33,52.89 80.03,52.59 79.05,52.59 78.08,51.63 78.08,47.25 78.44,46.89 82.98,46.89 83.91,45.95 83.91,44.04 U1001.A9
EMI0_DQ12: length 12.4
  TOP w0.075: 82.28,52.86 82.28,53.57 UD1.F9
  TOP w0.12: U1001.A11 84.72,44.04 84.72,44.46 84.93,44.67 84.93,44.96 84.76,45.12 84.76,46.18 84.89,46.3 84.89,51.21 84.5,51.59 82.75,51.59 82.28,52.05 82.28,52.86
EMI0_DQ13: length 13.6
  TOP w0.075: v8(81.59,52.51) 81.63,52.56 81.63,53.57 UD1.E9
  IN2 w0.075: v8(83.83,42.76) 83.88,42.8 83.88,47.66 83.69,47.85 83.69,48.16 83.48,48.37 83.48,49.37 83.88,49.77 83.88,51.85 83.43,52.29 82.38,52.29 82.33,52.24 81.86,52.24 v8(81.59,52.51)
EMI0_DQ14: length 17.6
  TOP w0.06: 83.64,44.14 83.59,44.09 83.59,43.46 83.83,43.21 U1001.C9
  TOP w0.12: 83.64,44.14 83.64,44.83 83.6,44.86 83.6,45.88 82.89,46.59 78.32,46.59 77.78,47.12 77.78,52.85 78.4,53.47 79.58,53.47 UD1.C9
EMI0_DQ15: length 16.1
  IN2 w0.075: v8(79.35,53.89) 79.68,53.57 83.96,53.57 84.73,52.81 84.73,50.45 84.96,50.22 84.96,47.03 84.67,46.74 84.67,42.79 v8(84.64,42.76)
EMI0_DQS0_C: length 10
  TOP w0.06: v8(80.75,48.75) 81.09,49.09 UD1.E3
  IN2 w0.06: v8(80.75,48.75) 80.82,48.82 80.82,48.99 80.74,49.07 80.11,49.07 79.66,48.62 79.3,48.62 78.77,48.1 78.77,46.69 80.25,45.21 80.25,44.95 80.61,44.59 81.19,44.59 81.56,44.21 81.56,43.5 81.83,43.23 v8(81.83,43.16)
EMI0_DQS0_T: length 10.1
  TOP w0.06: UD1.D3 80.75,49.19 v8(80.75,49.41)
  IN2 w0.06: v8(81.83,42.76) 81.63,42.96 81.63,43.26 81.44,43.45 81.44,44.16 81.14,44.47 80.56,44.47 80.13,44.9 80.13,45.16 78.65,46.63 78.65,48.15 79.25,48.74 79.61,48.74 80.06,49.19 80.63,49.19 80.75,49.32 v8(80.75,49.41)
EMI0_DQS1_C: length 16.5
  IN2 w0.06: v8(85.03,42.36) 85.03,46.4 85.3,46.66 85.3,50.5 85.13,50.67 85.13,53.26 84.01,54.37 81.15,54.37 80.91,54.61 80.91,54.76 81,54.85 81.15,54.85 v8(81.3,54.7)
EMI0_DQS1_T: length 16.5
  IN2 w0.06: v8(80.65,54.7) 81.1,54.25 83.96,54.25 85,53.21 85,50.62 85.18,50.45 85.18,46.71 84.91,46.45 84.91,42.57 84.83,42.49 84.83,42.16 v8(85.03,41.96)
EMI1_CA0: length 6.2
  IN2 w0.06: v8(87.03,42.76) 86.91,42.88 86.91,44.95 87.65,45.69 87.65,46.73 87.37,47.02 87.37,47.43 87.81,47.87 v8(87.81,48.3)
EMI1_CA1: length 5.5
  TOP w0.06: UD1.P2 87.16,47.89 86.87,47.6 86.87,45.69 86.54,45.36 86.54,44.47 86.48,44.42 86.48,43.41 U1001.C15
EMI1_CA2: length 12.5
  TOP w0.06: v8(88.5,51.19) 88.13,51.55 88.13,53.57 UD1.R9 ; v8(89.32,51.11) 89.43,51 89.43,47.24 87.18,44.99 87.18,44.16 87.27,44.06 87.27,43.8 U1001.B17
  IN2 w0.06: v8(88.5,51.19) 89.24,51.19 v8(89.32,51.11)
EMI1_CA3: length 12.1
  TOP w0.06: U1001.A17 87.02,43.97 87.02,45.11 88.78,46.87 88.78,54.14 88.6,54.32 88.18,54.32 UD1.R10
EMI1_CA4: length 13.4
  TOP w0.06: U1001.C17 86.8,43.4 86.8,44.06 86.83,44.1 86.83,45.2 88.15,46.52 88.15,51.12 87.47,51.8 87.47,55.16 UD1.R11
EMI1_CA5: length 22.5
  IN2 w0.06: v8(87.83,42.76) 87.83,42.94 87.51,43.26 87.51,44.7 88.75,45.94 88.75,47.31 88.85,47.41 88.85,50.07 90.04,51.27 91.9,51.27 93.32,52.69 93.32,54.73 92.09,55.97 89.97,55.97 89.73,55.72 87.38,55.72 v8(87.16,55.5)
EMI1_CK_C: length 13.4
  TOP w0.06: UD1.P9 87.16,53.68 87.11,53.64 86.93,53.64 86.78,53.49 86.78,51.73 87.47,51.05 v8(87.47,50.97)
  IN2 w0.06: v8(86.64,41.96) 86.83,42.16 86.83,42.47 86.67,42.63 86.67,45.01 87.43,45.77 87.43,46.65 87.11,46.98 87.11,47.49 87.54,47.92 87.54,49.22 87.37,49.39 87.37,50.88 v8(87.47,50.97)
EMI1_CK_T: length 13.3
  TOP w0.06: UD1.P8 87.16,53.45 87.09,53.52 86.98,53.52 86.9,53.44 86.9,51.78 87.35,51.34 87.51,51.18 v8(87.69,51.18)
  IN2 w0.06: v8(87.69,51.18) 87.39,51.18 87.25,51.04 87.25,49.34 87.42,49.17 87.42,47.97 87,47.54 87,46.92 87.32,46.61 87.32,45.82 86.56,45.06 86.56,42.52 86.64,42.44 v8(86.64,42.36)
EMI1_CKE0: length 8.7
  TOP w0.06: v8(87.6,49.54) 87.51,49.54 UD1.P4
  IN2 w0.06: v8(87.43,42.76) 87.43,42.91 87.21,43.13 87.21,44.83 87.96,45.57 87.96,46.66 88.19,46.89 88.19,48.54 87.95,48.79 87.95,49.13 88.13,49.31 88.13,49.55 88.02,49.65 87.72,49.65 v8(87.6,49.54)
EMI1_CKE1: length 10.2
  TOP w0.06: UD1.P5 87.53,50.32 v8(87.68,50.32)
  IN2 w0.06: v8(87.68,50.32) 88.2,50.32 88.32,50.2 88.49,50.2 88.67,50.01 88.67,47.43 88.6,47.35 88.6,46 87.37,44.77 87.37,43.19 87.64,42.92 87.64,42.56 v8(87.43,42.36)
EMI1_CS0: length 8.3
  TOP w0.06: UD1.R4 87.91,49.78 v8(87.91,49.45)
  IN2 w0.06: v8(87.03,42.36) 87.24,42.56 87.24,42.89 87.06,43.06 87.06,44.89 87.81,45.63 87.81,46.72 88.04,46.95 88.04,48.47 87.8,48.72 87.8,49.19 87.91,49.31 v8(87.91,49.45)
EMI1_CS1: length 6.4
  TOP w0.06: UD1.R3 87.5,48.79 87.5,46.08 86.68,45.27 86.68,44.17 86.64,44.13 86.64,43.17 U1001.C16
EMI1_DMI0: length 7.6
  TOP w0.06: 87.67,45.1 87.57,45 87.57,44.31 87.45,44.19 87.45,43.58 U1001.B18
  TOP w0.12: UD1.Y3 90.73,48.77 90.73,47.21 90.47,46.95 89.52,46.95 87.67,45.1
EMI1_DMI1: length 18.7
  TOP w0.075: v8(93.1,54.31) 91.44,54.31 UD1.Y10
  IN2 w0.075: v8(93.1,54.31) 93.08,54.29 93.08,52.75 91.81,51.48 87.38,51.48 86.59,50.7 86.59,47.02 87,46.61 87,45.82 86.33,45.15 86.33,43.65 v8(86.24,43.56)
EMI1_DQ0: length 7.8
  IN2 w0.06: v8(88.24,41.96) 88.43,42.16 88.43,42.47 88.59,42.62 88.59,43.24 88.49,43.33
  IN2 w0.075: v8(91.7,48.3) 91.7,47.63 88.49,44.42 88.49,43.33
EMI1_DQ1: length 7.3
  IN2 w0.06: 88.24,43.35 88.24,43.28 88.45,43.08 88.45,42.67 88.31,42.54 88.24,42.46 v8(88.24,42.36)
  IN2 w0.075: v8(91.05,48.3) 90.82,48.06 90.82,47.06 88.24,44.48 88.24,43.35
EMI1_DQ2: length 6.6
  IN2 w0.06: 88.02,43.33 88.02,43.25 88.24,43.03 v8(88.24,42.76)
  IN2 w0.075: 88.02,43.33 88.02,44.57 90.03,46.59 90.03,48.02 v8(89.75,48.3)
EMI1_DQ3: length 6.9
  IN2 w0.06: 87.78,43.24 88.03,42.99 88.03,42.56 v8(87.83,42.36)
  IN2 w0.075: 87.78,43.24 87.78,44.66 89.39,46.27 89.39,48.01 v8(89.1,48.3)
EMI1_DQ4: length 13.3
  TOP w0.06: v8(89.73,50.3) 91.15,50.3 91.38,50.06 91.38,49.82 91.59,49.62 92.07,49.62 ; 88.43,44.6 88.24,44.4 U1001.C20
  TOP w0.12: 88.43,44.6 89.88,46.05 91.56,46.05 92.79,47.29 92.79,49.17 92.48,49.49 92.19,49.49 92.07,49.62
  IN2 w0.075: v8(89.73,50.3) 89.51,50.3 v8(89.1,49.89)
EMI1_DQ5: length 9.8
  TOP w0.06: 87.83,44.86 87.75,44.78 87.75,44.22 87.61,44.08 87.61,43.79 U1001.B19
  TOP w0.075: 91.37,48.87 91.37,49.18 91.06,49.5 90.16,49.5 UD1.V4
  TOP w0.12: 87.83,44.86 89.63,46.67 90.73,46.67 91.37,47.31 91.37,48.87
EMI1_DQ6: length 9.1
  TOP w0.075: UD1.Y4 91.05,49.83 91.48,49.4 91.85,49.4 92.03,49.22 92.03,48.87
  TOP w0.12: 92.03,48.87 92.03,47.3 91.11,46.38 89.74,46.38 87.93,44.57 87.93,44.06 U1001.A19
EMI1_DQ7: length 11.4
  TOP w0.06: 88.51,44.27 88.4,44.17 88.4,43.39 U1001.C21
  TOP w0.12: UD1.AA4 92.09,50.28 92.56,50.28 93.12,49.72 93.12,47.23 91.67,45.78 90.02,45.78 88.51,44.27
EMI1_DQ8: length 20.5
  TOP w0.06: U1001.C13 85.08,43.51 85.08,44.16 85.35,44.42 85.35,44.46
  TOP w0.12: UD1.AA11 91.7,55.5 91.37,55.83 91.37,56.48 91.18,56.68 86.13,56.68 85.48,56.04 85.48,45.93 85.35,45.79 85.35,44.46
EMI1_DQ9: length 19.2
  IN2 w0.075: v8(85.83,43.16) 85.8,43.19 85.8,45.27 86.53,46 86.53,46.44 86.2,46.78 86.2,50.94 87.19,51.94 91.62,51.94 92.61,52.92 92.61,54.82 92.03,55.4 91.15,55.4 v8(91.05,55.5)
EMI1_DQ10: length 16
  TOP w0.12: U1001.A13 85.67,44.19 85.67,45.68 85.78,45.8 85.78,55.45 86.23,55.9 89.35,55.9 89.75,55.5 UD1.V11
EMI1_DQ11: length 22.1
  IN2 w0.075: v8(89.1,55.5) 89.81,55.5 90.07,55.75 92,55.75 92.83,54.91 92.83,52.83 91.71,51.71 87.28,51.71 86.4,50.82 86.4,46.9 86.77,46.53 86.77,45.91 86.07,45.21 86.07,43.8 86.03,43.76 86.03,43.4 86.24,43.19 v8(86.24,42.76)
EMI1_DQ12: length 15.5
  TOP w0.06: U1001.C12 85.03,43.33 84.94,43.43 84.94,44.28 85.14,44.48
  TOP w0.12: v2(85.13,54.26) 85.18,54.21 85.18,46.1 85.06,45.98 85.06,45.24 85.14,45.17 85.14,44.48 85.14,44.48
  IN2 w0.075: v2(85.13,54.26) 88.49,54.26 88.86,53.89 v8(89.1,53.89)
EMI1_DQ13: length 16
  TOP w0.12: U1001.A15 86.1,44.09 86.1,45.34 86.39,45.62 86.39,46.5 86.05,46.83 86.05,54.96 86.17,55.08 v8(86.17,55.1)
  IN2 w0.075: v8(89.75,53.89) 89.43,54.22 89.43,54.87 89.23,55.08 86.2,55.08 v8(86.17,55.1)
EMI1_DQ14: length 14.8
  TOP w0.12: v8(86.05,46.21) 86.11,46.16 86.11,45.73 85.88,45.5 85.88,43.61 U1001.B14
  IN2 w0.075: v8(91.05,53.89) 90.96,53.8 90.96,53.3 90.79,53.13 90.79,52.71 90.47,52.39 87,52.39 85.8,51.19 85.8,46.46 v8(86.05,46.21)
EMI1_DQ15: length 16.9
  IN2 w0.075: v8(85.83,42.76) 85.73,42.76 85.57,42.91 85.57,45.36 86.31,46.09 86.31,46.35 86,46.65 86,51.07 87.1,52.16 91.44,52.16 92.01,52.73 92.01,53.24 91.7,53.54 v8(91.7,53.89)
EMI1_DQS0_C: length 10.4
  IN2 w0.06: v8(88.64,42.36) 88.72,42.44 88.72,44.33 92.09,47.7 92.09,48.38 91.86,48.62 90.33,48.62 90.31,48.63 90.11,48.83 90.11,49.18 90.06,49.24 89.9,49.24 v8(89.75,49.1)
EMI1_DQS0_T: length 10.5
  IN2 w0.06: v8(88.64,41.96) 88.64,42.08 88.83,42.28 88.83,44.28 92.21,47.65 92.21,48.43 91.91,48.73 90.38,48.73 90.36,48.75 90.24,48.88 90.24,49.03 90.3,49.1 v8(90.4,49.1)
EMI1_DQS1_C: length 17.1
  IN2 w0.06: v8(85.43,41.96) 85.23,42.16 85.23,46.13 85.46,46.36 85.46,52.69 86.26,53.48 89.79,53.48 90.02,53.71 90.02,54.64 89.96,54.7 v8(89.75,54.7)
EMI1_DQS1_T: length 17
  IN2 w0.06: v8(90.4,54.7) 90.4,54.81 90.3,54.91 90.2,54.91 90.14,54.85 90.14,53.66 89.84,53.36 86.31,53.36 85.58,52.64 85.58,46.31 85.35,46.08 85.35,42.44 v8(85.43,42.36)
EMI_EXTR: length 2.8
  TOP w0.06: U1001.A2 80.95,43.96 80.72,44.19 80.6,44.19 80.6,44.19
  TOP w0.089: 80.6,44.19 79.45,44.19 79.36,44.29 R4001.2
EMI_RESET_N: length 19.3
  TOP w0.075: UD1.T11 88.87,55.08 93.29,55.08 93.29,55.08 v8(93.32,55.08)
  IN2 w0.06: v8(89.03,42.76) 89.05,42.78 89.05,44.19 92.69,47.83 92.69,51.74 93.48,52.53 93.48,54.91 v8(93.32,55.08)
EMI_VDD2: length 25.1
  TOP w0.06: v8(84.56,47.48) UD1.K1
  TOP w0.2: v8(82.32,48.47) 82.49,48.3 UD1.G2 ; v8(86.64,41.16) v8(85.43,41.16) ; UD1.H1 83.43,47.31 v8(83.43,47.21) ; v8(86.8,47.84) 86.8,47.84 86.51,47.55 UD1.N1 ; v8(86.81,48.83) 86.77,48.83 UD1.N3
  IN2 w0.1: v3(88.75,50.43) 88.39,50.43 88.25,50.57 87.93,50.57 v8(87.81,50.7)
  IN2 w0.15: v8(84.56,47.48) 84.56,47.75 84.24,48.06 84.24,48.34 84.01,48.58 84.01,49.04 84.16,49.19 v3(84.21,49.19)
  IN2 w0.2: v8(86.8,47.84) 87.02,48.06 v3(87.02,48.15) 87.02,48.62 v8(86.81,48.83) ; v8(87.81,56.3) 87.77,56.3 87.44,56.63 v3(87.44,56.65) 86.9,56.65 v3(86.8,56.55) 86.74,56.55 86.51,56.31 v8(86.51,56.3) ; v3(88.31,48.89) 88.45,48.74 v8(88.45,48.3) ; v8(89.1,50.7) 89.02,50.7 v3(88.75,50.43) ; v8(82.32,48.47) 82.35,48.44 v3(82.35,48.09) ; v8(87.81,47.5) 87.72,47.41 v3(87.72,47.16) ; v8(83.43,47.21) 83.43,46.99 83.34,46.89 83.34,46.83 v3(83.34,46.8) ; v8(89.1,53.1) 89.1,52.88 v3(89.24,52.74) ; v8(92.35,53.89) 92.35,53.91 92.07,54.2 v3(92.07,54.21) ; v3(88.01,52.74) 87.81,52.95 v8(87.81,53.1) ; v3(83.17,52.71) 83.17,53.01 v8(83.25,53.1) ; v8(78.7,49.89) 78.45,49.89 78.31,49.76 v3(78.29,49.76) ; v8(92.35,49.89) 92.35,50.03 v3(92.15,50.24) ; v8(81.95,53.1) 82.04,53.01 v3(82.04,52.7) ; v8(84.64,41.16) v3(84.64,41.51) ; v3(78.74,53.5) 78.7,53.54 v8(78.7,53.89) ; v8(81.96,50.7) 81.96,51.05 v3(82,51.09) ; v3(84.21,49.19) 84.46,49.19 v8(84.56,49.1) ; v3(83.49,51.01) 83.25,50.78 v8(83.25,50.7) ; v3(85.8,41.17) 85.78,41.16 ; 86.3,41.16 v3(86.29,41.17)
  IN2 w0.254: v3(84.84,55.99) 84.56,56.28 v8(84.56,56.3)
  IN2 w0.3: v3(83.56,56.59) 83.27,56.3 v8(83.25,56.3) 83.25,56.17 84.56,54.87 v8(84.56,54.7) ; 85.78,41.16 v8(85.43,41.16) ; v3(86.1,54.68) 86.12,54.7 v2(86.51,54.7) ; v8(86.64,41.16) 86.3,41.16
  IN2 w0.305: v3(86.29,41.17) v3(85.8,41.17)
  IN4 w0.178: v3(84.64,41.51) 84.56,41.58 v10(84.56,41.9) 84.62,41.95 v5(84.62,42.41)
  IN4 w0.2: v5(88.03,53.19) 88.03,52.76 v3(88.01,52.74) ; v5(86.97,48.62) 86.97,48.2 v3(87.02,48.15) ; v5(83.63,49.1) 83.7,49.18 84.14,49.18 84.16,49.19 v3(84.21,49.19) ; v5(92.55,54.37) 92.24,54.37 v3(92.07,54.21) ; v5(84.82,56.42) 84.84,56.39 v3(84.84,55.99) ; v5(83.15,52.28) 83.15,52.68 v3(83.17,52.71) ; v5(91.67,50.24) v3(92.15,50.24)
  vias: v1(83.68,58.76) v1(83.68,58.51) v1(83.95,58.76) v1(83.95,58.51) v1(106.19,47.41) v1(106.19,47.08) v1(106.19,46.78) v1(106.55,47.41) v1(106.55,47.08) v1(106.55,46.78) v1(106.9,47.41) v1(106.9,47.08) v1(106.9,46.78) v1(107.26,47.41) v1(107.26,47.08) v1(107.26,46.78) v1(107.61,47.41) v1(107.61,47.08) v1(107.61,46.78) v1(107.97,47.41) v1(107.97,47.08) v1(107.97,46.78) v1(113.44,41.56) v1(113.47,42.07) v1(113.47,41.81) v2(83.68,58.76) v2(83.68,58.51) v2(83.95,58.76) v2(83.95,58.51) v2(106.19,47.41) v2(106.19,47.08) v2(106.19,46.78) v2(106.55,47.41) v2(106.55,47.08) v2(106.55,46.78) v2(106.9,47.41) v2(106.9,47.08) v2(106.9,46.78) v2(107.26,47.41) v2(107.26,47.08) v2(107.26,46.78) v2(107.61,47.41) v2(107.61,47.08) v2(107.61,46.78) v2(107.97,47.41) v2(107.97,47.08) v2(107.97,46.78) v2(113.44,41.56) v2(113.47,42.07) v2(113.47,41.81) v3(78.34,51.65) v3(83.55,58.1) v3(83.95,58.1) v3(106.59,48.27) v3(106.59,47.87) v3(107.02,48.25) v3(106.99,47.84) v3(107.42,48.25) v3(107.41,47.82) v3(107.84,48.17) v3(107.82,47.77) v3(113.14,41.77) v3(113.39,41.23) v4(78.35,53.5) v4(78.38,51.32) v4(78.9,47.71) v4(78.9,47.46) v4(79.33,47.38) v4(79.36,49.87) v4(79.38,48.58) v4(79.54,47.61) v4(79.61,50.1) v4(79.59,48.73) v4(87.28,56.25) v5(78.35,53.5) v5(78.38,51.32) v5(78.9,47.71) v5(78.9,47.46) v5(79.33,47.38) v5(79.36,49.87) v5(79.38,48.58) v5(79.54,47.61) v5(79.61,50.1) v5(79.59,48.73) v5(87.28,56.25) v7(87.43,41.56) v9(85.83,41.51) v9(86.4,41.51) v10(85.83,41.51) v10(86.4,41.51)
EMI_VDD2_FB: length 53.4
  TOP w0.076: U2001.D11 v8(105.62,39.65)
  IN2 w0.076: v8(105.62,39.65) 105.23,39.65 104.96,39.92 104.76,39.92 104.75,39.92 v3(104.68,39.92)
  IN4 w0.076: v5(78.21,48.14) 78.01,48.34 78.01,48.47 77.58,48.9 77.58,53.77 77.86,54.04 77.86,55.3 78.52,55.96 78.99,55.96 81.8,58.77 91.96,58.77 97.3,53.43 97.3,49.47 98.42,48.35 103.14,48.35 103.41,48.08 103.97,48.08 105.15,46.91 105.15,43.62 106.15,42.62 106.15,41.38 105.27,40.49 105.14,40.49 104.75,40.11 104.75,40 v3(104.68,39.92)
  BOTTOM w0.076: SH4401.1 78.14,48.06 v5(78.21,48.14)
EMI_VDD2_GND: length 52.4
  IN2 w0.076: v8(105.62,40.05) 105.6,40.08 v3(105.29,40.08)
  IN4 w0.076: v3(105.29,40.08) 105.29,40.3 106.31,41.31 106.31,42.68 105.3,43.69 105.3,46.97 104.03,48.23 103.47,48.23 103.21,48.5 98.48,48.5 97.45,49.53 97.45,53.49 92.03,58.92 81.74,58.92 78.93,56.11 78.45,56.11 77.71,55.37 77.71,54.11 77.43,53.83 77.43,48.84 77.86,48.41 77.86,48.29 v5(77.71,48.14)
  BOTTOM w0.076: SH4402.1 77.78,48.06 v5(77.71,48.14)
EMI_VDDQ: length 22.7
  TOP w0.2: U1001.G15 86.86,41.56 87.03,41.38 v8(87.03,41.16) v8(87.83,41.16) ; U1001.G15 U1001.G14 ; U1001.G15 86.24,41.84 86.25,41.85 v8(86.25,41.87) ; U1001.G14 85.03,41.56 ; U1001.G14 85.83,41.85 v8(85.86,41.87) ; 85.03,41.56 84.43,41.56 84.24,41.36 U1001.H10 ; 85.03,41.56 v8(85.03,41.16)
  IN1 w0.2: v8(87.83,41.16) v8(87.03,41.16)
  IN2 w0.2: v8(81.95,49.1) 82,49.14 v3(82,49.42) ; v3(79.67,49.24) 79.5,49.24 v8(79.35,49.09) ; v8(90.4,50.7) 90.63,50.92 v3(90.7,50.92) 90.83,51.05 91.35,51.05 v8(91.7,50.7) ; v8(79.35,53.1) 79.47,52.98 v3(79.47,52.8) 79.47,52.4 79.61,52.27 80.12,52.27 80.58,52.72 v3(80.58,52.77) 80.58,53.02 v8(80.65,53.1) ; v8(89.1,49.1) 89.1,49.01 v3(89.35,48.77) ; v3(88.8,54.47) 89.03,54.7 v8(89.1,54.7) ; v8(90.4,53.1) 90.4,53.26 v3(90.59,53.45)
  IN2 w0.203: v3(80.56,47.19) 80.56,47.4 v8(80.65,47.5) ; v8(87.83,41.16) 87.74,41.07 v3(87.5,41.07) 87.13,41.07 v8(87.03,41.16) ; v8(91.7,53.1) 91.7,53.03 v3(91.45,52.77) ; v8(80.65,50.7) 80.6,50.75 v3(80.6,51.01) ; v8(90.4,47.5) 90.41,47.49 v3(90.41,47.17) ; v8(91.7,54.7) 91.7,54.64 v3(91.43,54.37) ; v3(91.43,49.4) 91.43,49.37 v8(91.7,49.1)
  IN2 w0.25: v3(80.6,51.01) 80.21,51.4 79.44,51.4 79.25,51.21 v3(79.25,50.99) 79.25,50.8 v8(79.35,50.7)
  IN2 w0.254: v3(90.72,56.56) 90.46,56.3 v2(90.4,56.3)
  IN2 w0.3: v3(85.2,41.55) 85.2,41.44 85.03,41.28 v8(85.03,41.16)
  IN4 w0.254: v5(87.91,41.9) 87.91,41.48 v3(87.5,41.07) ; v5(82.08,55.04) 81.85,55.04 v3(81.76,54.95) ; v3(79.47,52.8) 79.47,52.8 v5(79.47,53.17) ; v3(91.45,52.77) 91.3,52.91 v5(90.97,52.91) 90.59,53.29 v3(90.59,53.45)
  IN4 w0.305: v5(88.82,54.01) 88.82,54.45 v3(88.8,54.47) ; v5(89.78,48.69) 89.7,48.77 v3(89.35,48.77) ; v5(81.59,49.5) 81.92,49.5 v3(82,49.42)
  vias: v1(80.53,59.53) v1(80.65,56.35) v1(81.54,59.53) v1(82.56,59.53) v1(93.99,50.64) v1(93.99,50.33) v1(94.24,50.64) v1(94.24,50.33) v1(94.5,50.64) v1(94.5,50.33) v1(110.85,42.96) v1(110.85,42.68) v1(111.11,42.98) v1(111.11,42.73) v2(80.53,59.53) v2(80.65,56.35) v2(81.54,59.53) v2(82.56,59.53) v2(93.99,50.64) v2(93.99,50.33) v2(94.24,50.64) v2(94.24,50.33) v2(94.5,50.64) v2(94.5,50.33) v2(110.85,42.96) v2(110.85,42.68) v2(111.11,42.98) v2(111.11,42.73) v3(79.68,54.74) v3(80.35,55) v3(80.81,56) v3(86.25,42.21) v3(94.06,50) v3(94.47,50) v3(110.09,45.63) v3(110.32,45.98) v3(110.54,45.63) v7(79.35,54.7) v7(81.95,54.7) v7(109.22,41.25) v8(79.35,54.7) v8(81.95,54.7) v9(85.2,41.92) v9(85.51,41.92) v9(85.94,42.46) v9(86.54,42.47) v10(85.2,41.92) v10(85.51,41.92) v10(85.94,42.46) v10(86.54,42.47)
EMMC_VDDI: length 1.7
  IN2 w0.152: v2(102.47,56.81) 102.73,56.55 v3(102.95,56.55)
  IN4 w0.152: v5(103.27,56.35) 103.08,56.55 v3(102.95,56.55)
  BOTTOM w0.152: v5(103.27,56.35) C4419.2
EN_3V3_INA_H1: length 2.4
  TOP w0.089: R90751.2 47.92,10.47 48.06,10.32 Q748.3 R90991.1
EN_3V3_INA_H1_ODL: length 14.9
  TOP w0.089: U124.J1 57.58,15.41 58.74,14.24 58.74,14.24 v2(58.77,14.21) ; v2(51.85,8.97) 51.8,8.93 R90753.2 49.92,8.93 49.68,9.16 Q748.2
  IN2 w0.058: v2(58.77,14.21) 58.45,13.9 58.45,12.17 58.17,11.89 57.84,11.89 57.39,11.44 53.45,11.44 51.85,9.84 v2(51.85,8.97)
EN_LCD_BL: length 64
  TOP w0.089: D2738.1 45.79,36.96 49.08,36.96 49.56,37.45 50.1,37.45 50.58,37.93 50.58,38.81 51.11,39.34 51.11,41.1 51.16,41.15 v1(51.19,41.15)
  IN1 w0.06: 88.45,30.69 88.45,33.25 88.24,33.47 88.24,33.9 88.04,34.1 88.04,34.56 v7(87.83,34.76)
  IN1 w0.076: 88.45,30.69 88.02,30.26 88.02,29.47 87.59,29.04 87.59,28.89 87.23,28.53 87.23,27.84 87.16,27.77 87.16,26.33 86.51,25.69 86.01,25.69 85.66,25.34 85.66,24.96 85.37,24.67 83.64,24.67 83.47,24.5 79.83,24.5 77.02,27.31 76.13,27.31 74.05,29.39 74.05,30.66 72.4,32.31 70.14,32.31 69.78,32.67 68.13,32.67 67.39,31.93 64.39,31.93 62.12,34.2 62.01,34.2 61.05,35.16 60.18,35.16 60.08,35.26 58.45,35.26 57.26,36.46 55.99,36.46 55.74,36.71 55.74,36.94 51.52,41.15 v1(51.19,41.15)
EN_PP1800_MIPIBRDG: length 126.4
  TOP w0.089: R91230.1 71.53,53.84 71.42,53.96 67.9,53.96 67.46,53.52 67.46,50.22 66.66,49.41 63.61,49.41 63.53,49.49 60.34,49.49 59.2,48.34 58.26,48.34 56.3,46.39 54.74,46.39 v2(54.69,46.44)
  IN1 w0.06: v7(90.24,34.36) 90.31,34.36 90.84,33.84 91.13,33.84 91.38,33.59 91.38,33.03 90.99,32.65 90.99,31.85 91.05,31.79
  IN1 w0.076: 91.05,31.79 91.14,31.71
  IN1 w0.089: 91.14,31.71 91.14,31.34 91.61,30.87 91.61,29.62 92.85,28.37 92.85,26.94 94.53,25.26 94.53,23.38 93.84,22.69 93.66,22.69 93.61,22.64 v2(93.58,22.64)
  IN2 w0.058: v3(60.77,12.35) 61.98,13.57 64.64,13.57 66.03,12.18 73.16,12.18 73.34,12.36 74.38,12.36 75.97,13.95 75.97,15.42 76.22,15.68 77,15.68 77.7,16.37 78.04,16.37 78.11,16.44 78.98,16.44 79.05,16.52 79.05,17.15 79.3,17.4 83.88,17.4 84.02,17.54 87.09,17.54 88,18.45 89.25,18.45 93.44,22.64 v2(93.58,22.64) ; v3(54.31,46.31) 54.44,46.44 v2(54.69,46.44)
  IN4 w0.058: v3(54.31,46.31) 55.58,45.04 v4(55.58,43.47) ; v3(60.77,12.35) 60.77,12.86 61.17,13.26 v4(61.17,13.29)
  IN5 w0.076: v4(61.17,13.29) 60.59,13.29 58.73,15.15 58.73,15.57 57.94,16.36 57.94,16.54 55.65,18.84 55.65,19.3 54.63,20.32 53.59,20.32 53.26,20.65 53.26,21.88 53.26,24.34 54.04,25.13 59.97,25.13 61.86,27.01 61.86,35.24 61.62,35.47 60.96,35.47 59.08,37.34 59.08,37.6 54.9,41.78 54.9,42.78 v4(55.58,43.47)
EN_PP1800_S5_L: length 64.6
  TOP w0.089: v1(118.32,17.53) 118.52,17.33 118.52,16.82 117.71,16.01 116.59,16.01 116.45,15.87 115.67,15.87 114.82,15.02 114.82,13.19 113.6,11.97 105.95,11.97 104.1,13.82 104.1,14.89 103.4,15.58 103.06,15.58 102.68,15.2 101.35,15.2 100.52,14.36 100.52,13.6 100.81,13.3 R91268.1 ; v1(121.88,42.75) 120.25,44.38 120.25,47.5 120.94,48.19 121.82,48.19 R91196.2 122.39,48.09 124.01,48.09 124.34,48.41 U6517.A7
  IN1 w0.076: v1(118.32,17.53) 119.34,18.55 119.34,21.6 118.65,22.28 118.65,25.66 119.08,26.09 119.08,26.65 120.25,27.82 120.25,35.18 119.49,35.95 119.49,40.65 121.6,42.75 v1(121.88,42.75)
EN_PP3300_EDP_DX: length 119.6
  TOP w0.089: v2(49.28,42.83) 49.28,44.96 48.4,45.85 46.97,45.85 46.75,45.63 42.71,45.63 42.22,45.14 U6572.4
  IN1 w0.06: 90.79,32.46 90.79,32.65 91.07,32.92 91.07,33.2 90.65,33.62 90.65,33.83 90.32,34.16 90.03,34.16 v7(89.83,34.36)
  IN1 w0.076: v2(93.71,23.04) 94.29,23.63 94.29,25.17 92.62,26.84 92.62,28.27 91.37,29.52 91.37,30.77 90.79,31.35 90.79,32.46
  IN2 w0.058: v3(49.64,42.83) v2(49.28,42.83) ; v3(65.77,12.99) 66.36,12.39 73.07,12.39 73.25,12.57 74.29,12.57 75.76,14.03 75.76,16.76 75.3,17.22 75.3,18.41 75.79,18.9 76.09,18.9 77.38,17.61 83.78,17.61 83.92,17.75 87.01,17.75 87.91,18.66 89.17,18.66 93.55,23.04 v2(93.71,23.04)
  IN4 w0.058: v4(61.58,12.05) 61.93,12.4 61.93,12.86 62.29,13.21 64.98,13.21 65.21,12.99 v3(65.77,12.99) ; v4(50.55,43.72) 50.89,43.39 50.89,42.72 50.71,42.54 49.93,42.54 v3(49.64,42.83)
  IN5 w0.076: v4(61.58,12.05) 61.19,12.05 58.28,14.96 58.28,15.38 57.49,16.17 57.49,16.35 55.19,18.65 55.19,18.85 55.19,18.85 55.18,18.85 54.58,19.45 53.57,19.45 53.26,19.76 53.26,20.01 52.8,20.46 52.8,21.69 52.8,24.53 53.85,25.58 59.78,25.58 61.4,27.2 61.4,34.7 58.86,37.25 58.86,37.5 54.58,41.78 54.58,43.15 54.01,43.72 v4(50.55,43.72)
EN_PP3300_MIPIBRDG_DX: length 76.3
  IN1 w0.06: v7(89.43,34.76) 89.15,34.47 88.82,34.47 88.44,34.08 88.44,33.48 88.58,33.33 88.58,30.49
  IN1 w0.076: v1(35.49,40.44) 36.12,39.82 36.55,39.82 38.18,38.18 41.69,38.18 44.56,41.05 44.56,41.28 46.78,43.51 49.17,43.51 50.58,42.09 50.58,41.28 51.19,40.67 51.65,40.67 55.48,36.84 55.48,36.58 55.86,36.2 57.13,36.2 58.3,35.03 59.98,35.03 60.08,34.93 60.95,34.93 61.91,33.97 62.03,33.97 64.3,31.71 67.67,31.71 68.36,32.39 69.43,32.39 69.73,32.09 72.3,32.09 73.82,30.56 73.82,29.09 75.83,27.08 76.92,27.08 79.92,24.09 83.38,24.09 83.73,24.44 85.71,24.44 85.81,24.34 86.09,24.34 86.5,24.75 86.5,25.34 87.38,26.23 87.38,27.67 87.46,27.74 87.46,28.43 87.82,28.78 87.82,28.94 88.25,29.38 88.25,30.16 88.58,30.49
EN_PP5000_USBC: length 141.3
  TOP w0.089: U6559.1 138.5,12.31 138.39,12.2 136.28,12.2 135.64,11.56 135.26,11.56 134.63,12.2 v2(132.44,12.2)
  IN2 w0.058: v2(132.44,12.2) 132.31,12.34 129.32,12.34 128.8,11.82 127.75,11.82 127.42,11.49 124.65,11.49 120.5,7.34 91.57,7.34 88.6,10.32 86.14,10.32 85.13,11.33 81.48,11.33 80.16,10.82 79,10.33 75.19,6.52 73.71,6.52 72.28,5.09 70.16,5.09 v3(69.71,5.54)
  IN3 w0.102: v3(29.6,37.34) 29.82,37.12 32.02,37.12 33.51,35.62 33.51,34.68 33.79,34.4 34.58,34.4 37.09,31.88 37.09,25.89 38.49,24.49 39.96,24.49 42.05,22.41 42.05,20.17 42.43,19.79 42.43,16.06 43.21,15.27 52.15,15.27 52.33,15.45 54.21,15.45 54.79,16.03 57.01,16.03 57.59,15.45 57.95,15.45 59.09,14.31 59.98,14.31 60.16,14.13 60.16,12.71 60.31,12.55 60.31,11.92 62.21,10.01 63.34,10.01 64.33,9.02 66.91,9.02 68.28,7.66 68.28,6.98 69.71,5.55 v3(69.71,5.54)
  IN4 w0.058: v5(29.5,37.7) 29.6,37.6 v3(29.6,37.34)
  BOTTOM w0.089: R91172.1 29.43,38.97 29.6,38.79 29.6,37.8 v5(29.5,37.7)
EN_SPK_AMP: length 111.6
  IN1 w0.076: v2(26.5,14.74) 26.96,14.74 27.97,13.72 28.38,13.72 29.02,13.09 33.54,13.09 35.04,11.58 v1(35.04,10.91) 34.7,10.57 34.7,9.71 34.35,9.35 32.32,9.35 27.89,4.92 27.89,4.33 v1(27.68,4.12)
  IN2 w0.058: v8(89.04,34.76) 88.95,34.68 88.95,32.66 89.14,32.48 89.14,31.86 89.14,30.7 88.32,29.88 88.32,29.57 87.77,29.01 87.77,27.59 87.05,26.88 87.05,24.59 86.48,24.01 85.69,24.01 85.33,24.37 83.76,24.37 83.33,23.93 79.96,23.93 76.52,27.37 75.65,27.37 73.39,29.63 73.39,30.88 72.09,32.19 69.85,32.19 69.27,32.77 68.02,32.77 67.43,32.19 66.78,32.19 66.16,31.56 63.93,31.56 62.41,33.08 60.25,33.08 59.68,33.65 53.2,33.65 52.92,33.94 47.6,33.94 46.75,33.1 45.1,33.1 44.21,32.21 42.87,32.21 42.53,32.55 40.92,32.55 39.73,31.36 38.9,31.36 28.51,20.97 28.51,19.26 29.07,18.7 29.07,17.79 27.89,16.62 26.93,16.62 26.32,16.01 26.32,15.37 26.5,15.2 v2(26.5,14.74)
EN_USBA_5V: length 256.6
  TOP w0.089: U6517.A1 127.76,48 128.55,48 128.66,47.89 v2(128.66,47.81)
  IN1 w0.076: v1(89.37,31.55) 89.31,31.5 89.31,30.63 89.85,30.1 89.85,29.61 89.84,29.6 89.84,28.22 89.49,27.87 89.49,24.82 89.21,24.54 88.38,24.54 88.15,24.77 87.69,24.77 87.56,24.64 87.56,23.81 87.08,23.32 84.34,23.32 84.18,23.17 79.38,23.17 76.79,25.76 75.7,25.76 72.75,28.71 72.75,29.9 72.45,30.21 71.26,30.21 70.8,30.66 64.04,30.66 61.65,33.06 61.48,33.06 61.1,33.43 60.51,33.43 60.31,33.64 59.52,33.64 59.42,33.74 57.44,33.74 57.39,33.79 46.99,33.79 46.74,33.54 46.74,32.55 v2(46.12,31.93)
  IN2 w0.058: v2(128.66,47.81) 129.04,47.43 v3(129.04,46.41) ; v2(46.12,31.93) 45.89,31.7 44.93,31.7 44.57,31.34 43.43,31.34 42.93,30.84 41.4,30.84 40.44,29.88 40.2,29.88 39.86,29.54 38.53,29.54 37.37,28.38 37.37,26.45 v3(38.11,25.71)
  IN3 w0.102: v3(38.11,25.71) 39,24.82 40.09,24.82 42.36,22.55 42.36,20.29 42.73,19.92 42.73,16.19 43.34,15.58 51.9,15.58 52.08,15.75 54.08,15.75 54.72,16.39 57.99,16.39 59.44,14.94 60.21,14.94 60.77,14.38 60.77,13.44 61.55,12.65 61.55,11.56 62.49,10.62 63.59,10.62 64.57,9.64 69.49,9.64 70.49,10.63 85.72,10.63 86.88,9.47 88.9,9.47 91.13,7.23 114.73,7.23 116.34,8.85 121.54,8.85 122.86,10.17 139.84,10.17 143.06,13.39 143.06,19.35 142.21,20.2 142.21,22.4 142.53,22.72 142.53,29.09 143.75,30.31 143.75,32.31 145.02,33.58 145.78,33.58 145.78,33.59 146.16,33.59 147.18,32.57 147.18,31.5 147.79,30.89 149.06,30.89 150.22,32.06 150.22,35.18 148.44,36.96 147.94,36.96 147.56,36.58 146.99,36.58 145.18,38.39 143.52,38.39 141.74,40.16 137.1,40.16 136.95,40.32 134.43,40.32 v3(134.22,40.52) 134.22,40.67 131.22,43.67 130.46,43.67 128.94,45.19 128.94,46.31 v3(129.04,46.41)
  IN4 w0.058: v5(134.86,41.41) 134.86,41.03 134.35,40.52 v3(134.22,40.52)
