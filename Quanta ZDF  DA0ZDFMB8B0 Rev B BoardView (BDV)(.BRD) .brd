# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EN_USBC_CHARGE_L: length 160.8
  TOP w0.089: v2(43.95,8.97) 44.05,8.87 48.51,8.87 48.63,8.74 49.71,8.74 49.87,8.58 54.38,8.58 v2(54.46,8.66) ; U6559.39 136.89,17.28 v2(136.76,17.15) ; v1(32.43,44.53) 32.47,44.58 R91171.1
  IN1 w0.076: v2(32.62,20.33) 32.75,20.45 32.75,24.36 34.17,25.79 34.17,35.21 32.11,37.27 30.36,37.27 29.84,37.79 29.84,44.06 30.32,44.53 v1(32.43,44.53)
  IN2 w0.058: v2(54.46,8.66) 54.83,8.66 55.32,9.15 58.35,9.15 58.81,9.61 60.52,9.61 60.72,9.42 60.96,9.42 61.39,8.99 62,8.99 62.23,8.75 62.23,8.32 62.73,7.83 64.18,7.83 64.65,8.29 66.33,8.29 67.79,6.83 69.43,6.83 70.23,7.63 74.82,7.63 78.4,11.22 79.77,11.8 81.29,12.38 85.56,12.38 86.52,11.42 88.98,11.42 92.01,8.4 118.46,8.4 119.48,9.42 121.03,9.42 124.25,12.64 127.07,12.64 127.31,12.87 128.36,12.87 128.93,13.44 132.88,13.44 133.08,13.24 134.07,13.24 136.76,15.93 v2(136.76,17.15) ; v2(43.95,8.97) 43.62,8.97 41.79,10.8 38.18,10.8 34.6,14.38 34.15,14.38 33.41,13.65 29.85,13.65 28.81,14.68 28.81,15.27 28.68,15.4 28.68,15.73 28.84,15.88 28.84,16.36 32.62,20.15 v2(32.62,20.33)
EXT_PMIC_EN2: length 57.9
  TOP w0.089: v2(126.86,19.08) 126.8,19.02 126.8,17.65 127.54,16.92 127.54,14.18 127.54,14.17 127.54,13.29 v1(127.77,13.06)
  IN1 w0.06: 105.42,37.15 105.51,37.25 v7(105.62,37.25)
  IN1 w0.076: v1(127.77,13.06) 128.28,13.06 129.5,14.28 130.98,14.28 v1(131.43,14.73) ; v2(113.14,25.66) 112.86,25.66 112.68,25.84 108.24,25.84 107.86,25.46 106.43,25.46 105.93,24.95 103.31,24.95 103.03,25.23 v2(101.89,25.23) ; v2(104.42,35.28) 104.47,35.28 105.07,35.88 105.07,36.81 105.42,37.15
  IN2 w0.058: v2(113.14,25.66) 113.14,25.36 113.6,24.9 114.21,24.9 115.68,23.43 115.68,22.79 116.49,21.98 116.49,20.48 116.87,20.1 117.51,20.1 117.64,19.97 118.37,19.97 119.49,18.85 122.46,18.85 122.69,19.08 v2(126.86,19.08) ; v2(104.42,35.28) 104.46,35.28 104.52,35.22 104.52,31.85 104.06,31.38 103.65,31.38 102.75,30.49 102.75,30.35 102.6,30.2 102.6,28.98 103.77,27.81 103.77,26.78 104.22,26.32 104.22,25.63 104.11,25.52 103.77,25.52 103.24,26.04 102.22,26.04 101.89,25.71 v2(101.89,25.23)
FLASH_WP_ODL: length 177.8
  TOP w0.089: Q750.1 120.84,56.77 121.42,56.19 122.84,56.19 123.1,56.44 123.1,60.51 123.55,60.97 v2(123.55,62.39)
  IN2 w0.058: v2(44.56,22.98) 44.93,22.98 45.4,23.45 v3(45.63,23.45) ; v2(123.55,62.39) 122.64,62.39 122.46,62.57 120.76,62.57 120.07,63.25 118,63.25 116.84,64.41 77.78,64.41 76.44,63.07 76.44,62.07 73.9,59.53 73.9,52.27 72.83,51.2 72.83,50.76 72.52,50.44 69.02,50.44 68.41,51.04 66.45,51.04 64.46,49.06 63.59,49.06 62.84,48.31 60.81,48.31 59.48,46.98 58.28,46.98 58.16,46.85 57.06,46.85 55.34,45.14 53.21,45.14 52.81,45.54 45.37,45.54 45.27,45.45 42.63,45.45 42.32,45.75 40.53,45.75 39.51,44.73 39.07,44.73 38.49,44.15 37.55,44.15 36.02,42.63 34.86,42.63 32.52,40.29 32.52,35.11 32.19,34.78 v3(32.19,34.65)
  IN4 w0.058: v4(44.89,22.28) 45.04,22.43 45.04,22.87 v3(45.63,23.45) ; v3(32.19,34.65) 32.19,33.44 33.58,32.05 33.58,30.44 35.62,28.4 v5(35.62,27.95) 35.62,26.17 34.4,24.95 34.4,15.07 35.57,13.9 35.64,13.9 36.22,13.33 v5(36.22,13.09)
  IN5 w0.076: v4(44.89,22.28) 44.37,21.76 v5(44.37,21.22)
  BOTTOM w0.089: R512.2 38.18,12.21 37.02,13.37 36.49,13.37 v5(36.22,13.09) ; R90432.1 R90433.2 51.94,20.22 50.56,20.22 49.59,21.19 47.57,21.19 47.01,20.62 45.19,20.62 D2705.1 41.72,21.34 39.23,23.83 38.51,23.83 35.67,26.68 35.67,27.9 v5(35.62,27.95)
GP2: length 1.5
  TOP w0.089: U93.7 19.3,32.27 18.88,32.7 TP230.1
GP3: length 1.5
  TOP w0.089: U93.14 17.59,29 17.38,28.78 TP231.1
GP4: length 3
  TOP w0.089: U93.16 17.61,28.2 17.51,28.1 17.51,27.67 17.77,27.4 17.77,26.51 TP212.1
GP5: length 1.9
  TOP w0.089: U93.15 17.61,28.6 17.05,28.04 TP213.1
H1_AP_FLASH_CONTROL: length 6.2
  TOP w0.089: D2706.2 61.63,17.33 60.61,18.35 58.84,18.35 58.15,17.66 57.24,17.66 U124.H5
H1_BATT_PRES_ODL: length 107.6
  TOP w0.089: R91183.2 119.61,37.36 119.36,37.6 R91182.2 119.5,37.97 119.92,37.55 119.92,37.05 120.14,36.84 120.61,36.84 v2(120.73,36.96) ; v2(52.81,15.5) 53.09,15.5 53.19,15.41 U124.A1
  IN2 w0.058: v3(52.31,17.28) 52.81,16.77 v2(52.81,15.5) ; v2(120.73,36.96) v3(120.99,36.71)
  IN3 w0.102: v3(120.99,36.71) 121.09,36.61 121.09,35.74 120.3,34.96 120.3,28.02 120.89,27.44 120.89,27.26 120.89,27.26 120.89,26.84 120.89,26.84 120.89,18.78 119.89,17.78 119.89,15.36 116.02,11.49 115.63,11.49 114.58,10.44 114.58,9.44 113.91,8.77 91.75,8.77 89.52,11 87.59,11 86.44,12.16 69.86,12.16 69.62,11.92 64.45,11.92 62.29,14.08 62.29,16.64 62.11,16.82 60.8,16.82 60.65,16.97 60.39,16.97 59.72,17.63 58.56,17.63 57.41,18.78 54.89,18.78 54.27,19.4 52.72,19.4 52.1,18.78 52.1,17.48 v3(52.31,17.28)
H1_BOOT0: length 2.2
  TOP w0.089: U124.J3 58.51,16.41 58.81,16.11 R90448.1
H1_CCD_MODE_ODL: length 3.3
  TOP w0.089: U124.B1 53.5,14.92 53.5,14.15 R91147.1 53.67,13.57 53.45,13.34 R90380.2
H1_INT_OD_L: length 142.6
  TOP w0.089: R90560.2 96.99,43.3 96.45,42.75 v2(96.35,42.75) ; D2736.2 59.57,24.52 60.05,25 60.05,31.88 59.77,32.16 59.77,33.76 60.49,34.47 60.49,36.02 v1(60.56,36.1)
  IN1 w0.076: v2(96.35,42.75) 96.35,42.78 96.27,42.86 96.27,43.61 96.4,43.74 97.34,43.74 97.52,43.92 97.52,44.33 98.53,45.34 98.53,46.82 99.59,47.87 99.59,48.17 99.7,48.29 99.7,50.27 100.06,50.63 103.01,50.63 103.1,50.72 104.54,50.72 104.87,51.05 113.51,51.05 113.86,50.7 115.78,50.7 115.83,50.76 v2(115.83,50.81) ; v1(60.56,36.1) 61.26,36.1 62.17,35.19 65.82,35.19 66.53,35.9 v2(66.53,36.23)
  IN2 w0.058: v2(115.83,50.81) 116.02,50.81 v3(116.31,50.52) ; v2(66.53,36.23) 66.91,36.23 67.09,36.05 v3(67.12,36.05)
  IN2 w0.06: 91.82,40.65 91.72,40.65 91.14,40.07 89.14,40.07 v8(89.04,39.96)
  IN2 w0.075: 91.82,40.65 93.11,40.65 93.72,41.26 93.89,41.26 94.14,41.51 94.95,41.51 95.18,41.28 95.56,41.28 96.02,41.74 96.02,41.84 96.35,42.17 v2(96.35,42.75)
  IN3 w0.102: v3(67.12,36.05) 67.12,36.02 67.28,35.86 67.28,35.6 67.88,35.01 69.45,35.01 69.75,34.71 69.75,33.71 69.58,33.53 69.58,32.96 69.86,32.68 69.86,30.97 71,29.83 71,29.55 72.02,28.54 72.02,27.79 78.83,20.98 86.36,20.98 87.28,21.89 90.62,21.89 91.79,23.06 97.42,23.06 98.46,24.1 98.46,24.7 99.6,25.85 101.54,25.85 102.75,27.06 103.97,27.06 104.94,28.02 106.56,28.02 106.82,28.28 109.03,28.28 109.36,28.61 114.15,28.61 115.93,30.4 115.93,32.85 116.36,33.28 116.36,35.01 116.21,35.16 116.21,38.57 116.9,39.25 116.9,40.02 118.43,41.56 118.43,44.12 118.07,44.48 118.07,47.39 117.1,48.36 117.1,49.73 v3(116.31,50.52)
H1_KSI: length 3.4
  IN2 w0.058: v2(53.98,16.9) v3(53.55,16.9)
  IN4 w0.058: v4(53.07,16.52) 53.46,16.9 v3(53.55,16.9)
  IN5 w0.076: v5(52.57,15.04) 52.57,16.02 v4(53.07,16.52)
  BOTTOM w0.089: R3002.1 52.57,14.52 v5(52.57,15.04)
H1_PWR_BTN_ODL: length 66.2
  TOP w0.089: v2(51.43,17.28) 51.77,17.28 52.15,16.9 U124.A4
  IN2 w0.058: v2(51.43,17.28) 51.43,17.26 v3(51.19,17.02) ; v3(45.68,16.77) 45.68,16.41 43.67,14.41 43.67,11.84 44.03,11.49 v3(44.03,10.12) ; v3(6.6,23.58) 6.55,23.53 v2(6.55,22.79)
  IN3 w0.102: v3(6.6,23.58) 6.78,23.4 9,23.4 10.52,21.88 10.52,16.16 16.67,10.01 19.64,10.01 19.97,10.34 30.67,10.34 31.71,9.3 38.79,9.3 39.4,9.91 43.82,9.91 v3(44.03,10.12) ; v3(51.19,17.02) 47.23,17.02 46.92,16.72 45.73,16.72 v3(45.68,16.77)
  IN4 w0.058: v5(43.7,10.06) 43.73,10.09 44,10.09 v3(44.03,10.12)
  BOTTOM w0.089: v5(43.7,10.06) CON16.22
H1_RDCC1: length 16.4
  TOP w0.089: v1(62.59,9.43) 62.59,10.39 62.29,10.7 62.29,12.24 62,12.54 60.39,12.54 60.05,12.2 58.53,12.2 57.95,12.78 55.35,12.78 55.2,12.93 55.2,13.39 55.03,13.57 R91116.1 54.72,13.64 54.72,14.99 54.98,15.25 U124.D1
  IN1 w0.076: v1(62.59,9.43) 60.11,9.43 59.93,9.25 v1(59.8,9.25)
H1_RDCC2: length 21.2
  TOP w0.089: R90387.1 58.41,9.23 58.41,9.23 R91115.1 57.77,9.23 57.57,9.03 v2(57.57,8.74)
  IN2 w0.058: v2(54.98,15.9) 54.45,15.37 53.98,15.37 53.5,14.89 v3(53.48,14.89) ; v2(57.57,8.74) v3(57.82,8.49)
  IN4 w0.058: v4(53.7,15.3) 53.7,15.09 53.5,14.89 v3(53.48,14.89) ; v3(57.82,8.49) 58.17,8.13 58.56,8.13 58.91,8.49 59.72,8.49 60,8.77 60,9.07 59.75,9.33 59.39,9.33 58.91,9.8 v4(58.91,10.04)
  IN5 w0.076: v4(53.7,15.3) 53.7,14.71 53.45,14.46 52.64,14.46 51.85,13.67 51.85,13.19 51.9,13.14 51.9,12.13 52.69,11.33 54.67,11.33 55.63,10.37 58.58,10.37 v4(58.91,10.04)
H1_RST_ODL: length 34.3
  TOP w0.089: R90452.2 C10359.2 57.06,13.57 56.32,14.31 56.32,15.24 U124.G1 ; R90452.2 58.08,13.57 58.3,13.34 58.3,13.15 R90374.2 ; R90452.2 57.89,14.15 57.49,14.56 v2(56.65,14.56)
  IN2 w0.058: v3(39.73,5.72) 39.99,5.47 39.99,5.35 41.4,3.94 47.24,3.94 48.98,5.68 48.98,6.79 49.42,7.23 49.42,8.25 50.23,9.06 50.23,10.82 51.44,12.04 51.44,13.37 51.87,13.79 54.03,13.79 54.53,14.29 56.38,14.29 v2(56.65,14.56)
  IN4 w0.058: v5(39.35,5.72) v3(39.73,5.72)
  BOTTOM w0.089: CON16.45 38.9,5.27 v5(39.35,5.72)
H1_SBU1: length 101.6
  IN3 w0.089: v3(9.91,53.88) 9.77,54.03 9.46,54.03 9.38,53.94 9.38,53.43 9.46,53.35 11.31,53.35 11.71,52.95 13.67,52.95 17.72,48.9 17.72,47.02 18.05,46.7 18.74,46.7 20.95,44.48 20.95,43.27 20.71,43.03 20.71,39.17 19.31,37.78 19.06,37.78 17.99,36.71 13.82,36.71 11.93,34.83 11.93,27.4 13.47,25.86 13.47,23.02 13.2,22.75 13.2,21.22 14.84,19.59 14.84,19.28 16.45,17.67 16.45,14.69 17.57,13.57 17.84,13.57 18.35,13.06 18.35,12.74 18.59,12.5 28.71,12.5 28.86,12.66 39.28,12.66 39.77,13.15 45.98,13.15 46.55,12.58 47.39,12.58 48.24,11.72 49.23,11.72 49.73,11.22 50.95,11.22 52.43,12.71 52.43,12.78 v3(52.21,13.01)
  IN4 w0.056: v5(9.07,53.8) 9.07,54.36 9.12,54.41 9.2,54.41 9.5,54.11 9.68,54.11 v3(9.91,53.88) ; v5(53.58,13.98) 53.45,13.85 52.78,13.85 52.43,13.5 52.43,13.24 v3(52.21,13.01)
  BOTTOM w0.071: v5(53.58,13.98) 53.58,14.87 53.45,14.99 53.45,15.5 53.55,15.6 Q807.3 53.86,15.09 53.99,14.96 R91311.1
H1_SBU2: length 101.3
  IN3 w0.089: v3(52.82,13.03) 52.67,12.89 52.68,12.88 52.68,12.61 51.05,10.98 49.63,10.98 49.13,11.48 48.14,11.48 47.29,12.34 46.45,12.34 45.88,12.91 39.87,12.91 39.38,12.41 28.96,12.41 28.81,12.26 18.49,12.26 18.11,12.64 18.11,12.96 17.74,13.33 17.47,13.33 16.21,14.59 16.21,17.57 14.6,19.18 14.6,19.49 12.96,21.12 12.96,22.85 13.23,23.12 13.23,25.76 11.69,27.3 11.69,34.93 13.72,36.95 17.89,36.95 18.96,38.02 19.21,38.02 20.47,39.27 20.47,43.13 20.71,43.37 20.71,44.38 18.64,46.46 17.95,46.46 17.48,46.92 17.48,48.8 13.57,52.71 11.61,52.71 11.21,53.1 9.36,53.1 9.13,53.33 9.13,54.04 9.36,54.27 9.62,54.27 v3(9.85,54.5)
  IN4 w0.056: v5(9.07,55.24) 9.07,54.67 9.12,54.62 9.28,54.62 9.58,54.32 9.66,54.32 v3(9.85,54.5) ; v3(52.82,13.03) 52.64,13.21 52.64,13.42 52.87,13.65 53.4,13.65 v5(53.58,13.47)
  BOTTOM w0.071: R91313.1 53.99,13.37 53.86,13.25 Q808.3 53.58,12.86 53.45,12.99 53.45,13.34 v5(53.58,13.47)
H1_UART_VREF: length 3.9
  TOP w0.203: Q727.3 42.53,5.34 42.56,5.31 v2(42.56,4.83)
  IN2 w0.203: v2(42.56,4.83) 42.56,4.9 42.17,5.29 v3(42.17,5.34)
  IN4 w0.203: v3(42.17,5.34) 41.89,5.34 v5(41.77,5.21)
  BOTTOM w0.203: CON16.29 42.1,4.88 v5(41.77,5.21)
HOMEKEY: length 17.7
  TOP w0.089: v7(106.94,40.86) 106.83,40.86 U2001.G13 ; v1(113.67,49.37) 114.19,48.85 115.32,48.85 115.58,48.6 D2707.2
  IN1 w0.076: v7(106.94,40.86) 107.43,40.86 107.8,41.23 107.8,42.24 107.88,42.32 107.88,44.34 108.59,45.05 108.59,48.07 108.44,48.22 108.44,48.93 108.59,49.08 113.39,49.08 v1(113.67,49.37)
HP_INT_ODL: length 121.7
  IN2 w0.058: v3(99.61,33.98) 99.64,33.98 99.85,33.77 v2(99.96,33.77) ; v2(11.36,25.48) 12.81,25.48 12.94,25.61 12.94,27.26 v3(13.55,27.87) ; v3(97.32,35.77) 97.28,35.73 95.09,35.73 94.62,36.2 v2(94.61,36.2) ; v3(70.18,33.01) 69.79,33.4 67.75,33.4 67.17,32.82 66.52,32.82 65.9,32.19 64.19,32.19 62.67,33.72 60.62,33.72 58.95,35.38 53.01,35.38 52.46,34.83 47.22,34.83 46.34,33.94 43.55,33.94 43.23,33.62 42.4,33.62 42.17,33.39 40.32,33.39 39.19,32.26 38.23,32.26 36.94,30.97 32.19,30.97 v3(32.01,31.15)
  IN3 w0.102: v3(13.55,27.87) 14.05,28.38 14.05,29.06 14.21,29.22 15.32,29.22 15.93,29.83 15.93,30.2 16.62,30.88 18.59,30.88 18.86,31.15 23.15,31.15 23.45,30.84 24.86,30.84 25.33,31.32 25.33,32.26 26.88,33.81 28.48,33.81 29.17,33.13 30.03,33.13 v3(32.01,31.15) ; v3(99.61,33.98) 99.61,33.95 99.58,33.92 99.58,33.14 99.73,32.99 99.73,32.01 99.98,31.76 99.98,29.5 99.37,28.88 99.37,27.29 95.44,23.37 91.63,23.37 90.46,22.2 87.15,22.2 86.24,21.28 78.95,21.28 72.32,27.92 72.32,28.66 71.66,29.33 71.66,29.61 70.72,30.54 70.72,32.47 v3(70.18,33.01)
  IN4 w0.058: v5(98.15,35.41) 97.8,35.41 97.44,35.77 v3(97.32,35.77) ; v5(99.37,34.25) 99.47,34.25 99.61,34.11 v3(99.61,33.98)
  BOTTOM w0.089: v5(99.37,34.25) 99.37,34.55 98.51,35.41 v5(98.15,35.41)
HP_L: length 30.6
  TOP w0.203: R90764.2 15.02,25.2 15.02,26.1 14.47,26.65 R90778.2 R90777.2 15.51,27.22 ESD6206.2 15.51,28.48 15.59,28.57 15.59,30.5 15.4,30.69 15.4,32.16 15.6,32.37 15.6,33.84 14.08,35.36 14.08,36.05 16.42,38.39 16.42,47.81 15.58,48.65 CON6201.1
HP_R: length 2
  TOP w0.508: 7.48,37.24 7.25,37.47 CON6201.2
HPCSN: length 2.3
  TOP w0.203: U6504.C1 11.84,28.88 10.66,27.7 C9048.1
HPCSP: length 3.1
  TOP w0.203: C9049.1 8.95,27.06 9.96,28.06 10.25,28.06 U6504.A1
I2C_SCL_INA: length 49.8
  IN2 w0.058: v3(36.74,7.75) 36.89,7.6 37.42,7.6 38.08,6.94 39.42,6.94 39.56,6.81 39.56,6.5 39.11,6.05 39.11,5.54 39.36,5.29 39.36,4.52 40.31,3.57 47.34,3.57 49.31,5.55 49.31,6.62 49.79,7.11 49.79,8.16 50.55,8.92 50.55,10.6 51.8,11.85 51.8,13.18 52.05,13.42 54.17,13.42 54.68,13.94 57.38,13.94 58.45,15 58.71,15 58.98,15.27 58.98,15.85 57.31,17.52 57.31,17.73 v2(57.48,17.91)
  IN4 w0.058: v5(36.38,7.75) v3(36.74,7.75)
  BOTTOM w0.089: Q80.1 39.33,13.51 39.28,13.46 38.26,13.46 R90481.2 37.61,13.15 37.14,13.62 36.25,13.62 34.03,11.39 34.03,8.52 34.79,7.75 v5(36.38,7.75)
I2C_SCL_INA_SERVO: length 314.8
  TOP w0.089: U6526.6 121.72,18.87 122.2,19.35 v2(122.2,19.64) ; v1(47.18,41.43) 47.28,41.33 47.58,41.33 47.81,41.1 49.06,41.1 49.13,41.18 49.13,42.12 49.67,42.65 49.67,44.86 50.9,46.1 52.56,46.1 52.75,45.91 52.75,45.71 52.99,45.47 ; U6530.5 53.64,45.41 53.58,45.47 52.99,45.47 ; 52.99,45.47 U6530.6
  IN1 w0.076: v2(45.58,32.01) 45.43,32.15 45.25,32.15 44.17,33.23 44.17,39.15 46.27,41.26 47,41.26 v1(47.18,41.43) ; v2(123.49,32.95) 123.62,32.82 123.81,32.82 123.99,32.64 123.99,32.32 123.2,31.53 123.2,25.15 122.08,24.03 122.08,19.75 v2(122.2,19.64)
  IN2 w0.058: v3(123.2,33.11) 123.36,32.95 v2(123.49,32.95) ; v3(126.63,61.23) 126.9,60.97 127.36,60.97 127.92,60.41 127.92,59.7 127.36,59.14 127.36,58.64 128,58.01 131.01,58.01 131.52,57.49 131.52,56.88 131.39,56.75 131.39,55.19 131.91,54.67 131.91,53.84 132.62,53.13 132.62,49.94 132.93,49.64 132.93,45.61 132.62,45.31 132.62,43.86 133.29,43.19 136.8,43.19 139.3,40.68 139.3,37 140.66,35.64 140.66,35.09 141.2,34.56 141.2,25.1 140.56,24.47 140.56,23.12 139.78,22.34 134.94,22.34 132.17,19.57 126.89,19.57 126.61,19.29 123,19.29 122.34,19.95 122.16,19.95 122.07,19.85 122.07,19.77 122.2,19.64 v2(122.2,19.64) ; v3(40.55,9.35) 40.55,7.73 40.17,7.35 38.65,7.35 35.67,10.33 34.25,10.33 32.03,12.55 29.83,12.55 29.64,12.37 20.94,12.37 20.53,11.96 16.91,11.96 15.3,13.57 15.3,16.79 15.4,16.89 15.48,16.89 v2(15.75,16.62) 16.02,16.89 16.11,16.89 16.2,16.8 16.2,14.91 17.37,13.74 18.42,13.74 18.69,13.47 25.97,13.47 27.89,15.39 27.89,16.15 30.53,18.79 30.53,21.84 38.45,29.76 39.73,29.76 39.86,29.89 39.86,29.9 v2(40.19,30.22) 39.92,30.49 39.92,30.57 39.98,30.63 40.39,30.63 40.91,31.15 42.93,31.15 43.34,31.56 44.49,31.56 45.08,32.15 45.43,32.15 v2(45.58,32.01) 45.75,32.18 45.92,32.18 46.01,32.27 46.29,32.27 46.83,31.72 47.3,31.72 47.41,31.84 47.41,31.97 v3(47.68,32.24)
  IN3 w0.102: v3(129.09,62.9) 129.09,62.92 129.29,63.13 129.29,65.01 130.01,65.72 130.01,66.1 128.46,67.65 124.49,67.65 124.04,67.19 75.99,67.19 71.73,62.93 71.3,62.93 67.22,58.85 67.22,54.41 64.19,51.39 64.19,49.55 63.81,49.17 63.81,48.34 63.15,47.68 63.15,46.89 61.27,45.01 61.27,43.63 61.96,42.94 61.96,40.39 61.3,39.73 61.3,38.51 56.6,33.81 50.27,33.81 49.23,32.77 47.64,32.77 47.46,32.6 47.46,32.48 v3(47.68,32.24)
  IN4 w0.058: v5(129.17,62.29) 129.34,62.46 129.34,62.75 129.19,62.9 v3(129.09,62.9) ; v3(40.55,9.35) 40.5,9.4 v5(40.5,9.84) ; v5(122.68,33.24) 123.07,33.24 v3(123.2,33.11) ; v3(126.63,61.23) 126.43,61.43 v5(126.25,61.43)
  BOTTOM w0.089: Q80.4 40.34,11.97 40.23,11.86 R90483.2 40.23,10.11 v5(40.5,9.84) CON16.38 ; v5(126.25,61.43) 126.95,61.43 127.18,61.2 127.69,61.2 128.68,60.2 129.17,60.2 129.27,60.3 129.27,60.44 129.03,60.67 U6538.5 129.03,62.15 v5(129.17,62.29) ; U6540.5 v5(122.68,33.24)
I2C_SDA_INA: length 36.3
  TOP w0.089: v2(39.95,6.17) 39.92,6.14 39.87,6.14 39.71,5.98 38.58,5.98 R90482.2 38.84,5.73 38.88,5.69 Q81.1
  IN2 w0.058: v2(39.95,6.17) 39.92,6.17 39.89,6.2 39.43,6.2 39.23,6 39.23,5.59 39.48,5.34 39.48,4.57 40.36,3.69 47.29,3.69 49.19,5.59 49.19,6.67 49.68,7.16 49.68,8.21 50.44,8.97 50.44,10.65 51.68,11.9 51.68,13.22 52,13.54 54.12,13.54 54.63,14.05 57.34,14.05 58.4,15.12 58.66,15.12 58.86,15.32 58.86,15.81 57.19,17.47 57.19,17.69 v2(56.98,17.91)
I2C_SDA_INA_SERVO: length 321.7
  TOP w0.089: v1(47.2,41) 47.35,41.15 47.5,41.15 47.73,40.93 49.13,40.93 49.31,41.1 49.31,42.05 49.84,42.58 49.84,44.79 50.98,45.92 52.48,45.92 52.57,45.83 52.57,45.71 52.34,45.47 U6530.7 ; 121.07,18.73 121.78,19.44 v2(121.78,19.67) ; 121.07,18.73 120.96,18.84 120.96,19.16 121.37,19.56 121.37,19.87 121.57,20.07 122.44,20.07 122.69,19.82 122.69,19.08 122.37,18.76 U6526.5 ; 121.07,18.73 U6526.7 ; v2(41.08,5.21) 41.38,5.21 41.64,4.96 R90484.2 41.58,4.65 41,4.65 40.67,4.99 Q81.4
  IN1 w0.076: v1(47.2,41) 47.1,41.1 46.34,41.1 44.32,39.09 44.32,33.29 45.31,32.3 45.45,32.3 v2(45.6,32.46) ; v2(121.78,19.67) 121.93,19.82 121.93,24.1 123.05,25.22 123.05,31.6 123.84,32.39 123.84,32.58 123.75,32.67 123.67,32.67 v2(123.52,32.52)
  IN2 w0.058: v3(123.2,32.46) 123.46,32.46 v2(123.52,32.52) ; v2(41.08,5.21) 40.72,5.21 v3(40.55,5.39) 40.8,5.64 41.11,5.64 41.41,5.95 41.41,6.76 40.94,7.24 38.6,7.24 35.62,10.22 34.2,10.22 31.98,12.44 29.88,12.44 29.69,12.25 20.99,12.25 20.58,11.84 16.86,11.84 15.18,13.52 15.18,16.84 15.35,17.01 15.48,17.01 v2(15.75,17.27) 16.02,17.01 16.16,17.01 16.32,16.85 16.32,14.95 17.41,13.86 18.47,13.86 18.74,13.58 25.92,13.58 27.77,15.44 27.77,16.2 30.41,18.84 30.41,21.89 38.4,29.88 39.68,29.88 39.74,29.93 39.74,30.02 v2(39.54,30.22) 39.8,30.49 39.8,30.62 39.93,30.75 40.35,30.75 40.86,31.26 42.89,31.26 43.29,31.67 44.44,31.67 45.03,32.27 45.42,32.27 v2(45.6,32.46) 45.76,32.3 45.87,32.3 45.96,32.38 46.33,32.38 46.88,31.84 47.25,31.84 47.3,31.89 47.3,31.99 v3(47.02,32.26) ; v2(121.78,19.67) 121.95,19.84 121.95,19.9 122.11,20.06 122.39,20.06 123.04,19.41 126.56,19.41 126.84,19.69 132.13,19.69 134.89,22.46 139.73,22.46 140.44,23.17 140.44,24.52 141.08,25.15 141.08,34.51 140.55,35.04 140.55,35.59 139.19,36.95 139.19,40.63 136.75,43.07 133.25,43.07 132.5,43.81 132.5,45.36 132.81,45.66 132.81,49.59 132.5,49.89 132.5,53.08 131.79,53.79 131.79,54.62 131.28,55.14 131.28,56.8 131.41,56.93 131.41,57.44 130.96,57.89 127.95,57.89 127.25,58.59 127.25,59.19 127.81,59.74 127.81,60.36 127.31,60.85 126.76,60.85 v3(126.54,60.62)
  IN3 w0.102: v3(129.7,62.9) 129.7,62.92 129.5,63.12 129.5,64.92 130.21,65.63 130.21,66.18 128.54,67.85 124.41,67.85 123.95,67.39 75.91,67.39 71.64,63.13 71.21,63.13 67.01,58.93 67.01,54.49 63.99,51.47 63.99,49.64 63.61,49.26 63.61,48.43 62.95,47.77 62.95,46.97 61.07,45.09 61.07,43.54 61.76,42.86 61.76,40.48 61.1,39.82 61.1,38.6 56.52,34.02 50.19,34.02 49.15,32.98 47.56,32.98 47.26,32.68 47.26,32.48 v3(47.02,32.26)
  IN4 w0.058: v5(129.62,62.29) 129.46,62.45 129.46,62.76 129.6,62.9 v3(129.7,62.9) ; v5(122.68,32.59) 123.07,32.59 v3(123.2,32.46) ; v3(40.55,5.39) 40.55,5.29 v5(40.88,4.96) ; v3(126.54,60.62) 126.38,60.78 v5(126.25,60.78)
  BOTTOM w0.089: CON16.37 40.5,4.71 40.75,4.96 v5(40.88,4.96) ; v5(126.25,60.78) 126.93,60.78 127.16,61.02 127.62,61.02 128.61,60.03 129.24,60.03 129.44,60.23 129.44,60.46 129.68,60.69 U6538.6 129.68,62.23 v5(129.62,62.29) ; v5(122.68,32.59) U6540.6 120.87,32.59 120.76,32.48 120.76,32.06 120.88,31.94 U6540.7
I2S0_DI: length 138.5
  IN1 w0.06: 88.09,32.39 88.09,33.19 87.83,33.45 v7(87.83,33.56)
  IN1 w0.076: 88.09,32.39 88.09,30.99 87.36,30.26 87.36,29.11 v1(87.26,29.01) 87,28.76 87,27.95 86.93,27.87 86.93,26.42 86.42,25.91 85.91,25.91 85.43,25.43 85.43,25.05 85.28,24.9 83.54,24.9 83.37,24.73 79.93,24.73 78.7,25.96 78.7,27.84 78.62,27.92 77.1,27.92 75.8,29.22 75.8,30.44 v2(75.62,30.61)
  IN2 w0.058: v3(71.13,52.69) 71.76,53.32 71.76,57.59 71.95,57.78 71.95,59.38 75.08,62.5 75.08,63.55 77.2,65.68 117.37,65.68 118.52,64.52 123.14,64.52 123.87,65.25 126.28,65.25 126.65,64.88 127.87,64.88 128.05,64.7 129.93,64.7 130.06,64.57 130.49,64.57 v3(130.67,64.4) ; v2(75.62,30.61) 75.52,30.71 75.52,32.39 73.19,34.73 72.53,34.73 72.23,35.03 71.15,35.03 v3(71.1,34.98)
  IN3 w0.102: v3(71.1,34.98) 70.77,35.31 68,35.31 67.58,35.73 67.58,36.98 66.96,37.6 66.96,40.01 67.09,40.14 67.09,41.84 67.29,42.04 67.29,43.19 67.83,43.72 67.83,44.51 67.72,44.61 67.72,45.93 67.02,46.64 67.02,47.46 67.88,48.32 68.44,48.32 70.28,50.16 70.28,51.83 v3(71.13,52.69)
  IN4 w0.058: v5(131.12,63.86) 131.12,63.94 v3(130.67,64.4)
  BOTTOM w0.089: U1007.60 141.39,59.72 141.39,60.4 139.89,61.9 133.09,61.9 v5(131.12,63.86)
I2S2_BCK: length 167.1
  TOP w0.089: v1(13.01,30.94) 13.01,30.89 12.73,30.61 12.47,30.61 U6504.D6 ; v1(25.56,4.94) 25.51,4.99 U6503.C1
  IN1 w0.06: 80.25,35.42 80.38,35.29 80.56,35.29 81.18,35.91 81.18,36.03 81.3,36.15 81.73,36.15 81.73,36.16 82.03,36.16 v7(82.24,36.36)
  IN1 w0.076: 80.25,35.42 80.07,35.59 80.07,35.98 79.44,36.6 79.15,36.6 78.9,36.85 78.9,37.24 75.92,40.21 74.58,40.21 74.28,40.52 74.28,42.42 73.96,42.74 73.66,42.74 73.02,42.1 73.02,39.68 72.9,39.56 71.75,39.56 71.08,38.89 68.26,38.89 66.99,40.16 64.34,40.16 63.5,39.33 61.34,39.33 60.79,38.77 60.79,37.88 61.31,37.36 61.31,36.7 61.02,36.4 60.66,36.4 60.61,36.46 58.53,36.46 56.37,38.61 55.99,38.61 54.72,39.88 54.59,39.88 54.08,40.39 54.08,42.81 52.54,44.35 46.36,44.35 43.92,41.92 43.29,41.92 42.81,41.43 42.81,40.67 42.2,40.06 38.56,40.06 37.55,41.07 37.55,43.1 35.08,45.57 34.83,45.81 30.95,45.81 29.38,44.25 29.38,39.21 26.68,36.51 26.68,35.87 25.15,34.35 25.15,30.59 25.54,30.21 25.54,29.59 25.38,29.44 25.38,20.55 v2(25.13,20.3) ; v7(32.26,11.05) 32.26,11.14 32.03,11.37 31.2,11.37 31.12,11.29 31.12,8.8 27.59,5.26 25.88,5.26 v1(25.56,4.94) 25.27,4.65 24.16,4.65 24,4.81 20.84,4.81 19.26,6.39 19.26,9.28 14.69,13.86 14.69,18.41 v2(15.01,18.73) 15.01,20.11 16.8,21.89 16.8,24.65 16.32,25.13 14.66,25.13 14.38,24.85 13.71,24.85 13.39,25.16 13.39,25.79 14.59,26.98 14.59,29.01 13.7,29.9 13.7,30.44 13.2,30.94 v1(13.01,30.94)
  IN2 w0.058: v2(15.01,18.73) 15.34,19.06 18.83,19.06 19.39,18.5 20.86,18.5 22,17.35 23.75,17.35 24.05,17.66 24.05,18.93 25.13,20 v2(25.13,20.3)
I2S2_DI: length 83.4
  TOP w0.075: U1001.AA2 80.8,36.19 80.5,36.19 80.48,36.17 80.3,36.17
  TOP w0.089: v2(79,36.05) 79.46,36.05 79.58,36.17 80.3,36.17 ; v1(15.38,35.77) 15.38,35.97 17.2,37.8 17.2,40.95 17.88,41.63 19.22,41.63 20.55,40.29 23.47,40.29 26.78,36.99 30.08,36.99 30.54,36.53 38.21,36.53 39.48,35.26 v2(39.48,35.13)
  IN1 w0.076: v1(15.38,35.77) 15.38,35.64 14.82,35.08 14.82,34.42 13.39,32.99 13.39,31.9 12.99,31.5 12.21,31.5 v1(11.84,31.13)
  IN2 w0.058: v2(79,36.05) 78.7,36.05 78.52,35.87 78.19,35.87 77.33,36.73 76.67,36.73 74.02,39.38 68.65,39.38 68.17,39.85 61.88,39.85 60.89,38.87 57.26,38.87 57.18,38.79 55.9,38.79 55.74,38.64 54.29,38.64 52.04,36.39 43.24,36.39 42.87,36.01 41.98,36.01 41.32,35.36 40.82,35.36 40.63,35.54 39.81,35.54 39.48,35.21 v2(39.48,35.13)
I2S2_LRCK: length 136.7
  TOP w0.089: v1(15.95,34.91) 15.95,35.86 17.69,37.6 17.69,40.75 18.08,41.15 19.02,41.15 20.35,39.81 23.27,39.81 26.58,36.51 29.88,36.51 30.34,36.05 37.42,36.05 38.44,35.03 38.95,35.03 v2(39.07,35.16) ; v1(26.02,4.93) 26.02,4.98 25.21,5.79 U6503.C3 ; U6504.D8 12.26,30.94 v1(12.61,30.94) 12.61,31.27 13.24,31.91 13.24,32.44 13.6,32.8 14.26,32.8 14.38,32.67 14.68,32.67 v1(14.81,32.8)
  IN1 w0.06: v7(81.41,35.95) 81.4,35.95 80.5,35.06 80.32,35.06 80.21,35.17
  IN1 w0.076: v1(12.61,30.94) 12.61,30.89 12.89,30.61 13.2,30.61 13.47,30.35 13.47,29.8 14.36,28.91 14.36,27.08 13.17,25.88 13.17,25.06 13.61,24.62 14.47,24.62 14.75,24.9 16.23,24.9 16.57,24.56 16.57,21.99 14.46,19.88 14.46,13.76 19.03,9.19 19.03,6.17 20.63,4.57 23.92,4.57 24.06,4.43 25.51,4.43 v1(26.02,4.93) 26.12,5.04 27.68,5.04 31.35,8.71 31.35,10.95 v7(31.46,11.05) ; 80.21,35.17 80.16,35.17 79.94,35.39 79.15,35.39 78.67,35.87 78.67,37.14 75.83,39.99 74.34,39.99 v2(74.29,39.93) ; v1(15.95,34.91) 15.95,33.27 15.36,32.68 14.93,32.68 v1(14.81,32.8)
  IN2 w0.058: v2(74.29,39.93) 73.95,39.59 68.73,39.59 68.26,40.06 61.79,40.06 60.81,39.08 57.01,39.08 56.95,39.02 55.77,39.02 55.62,38.87 54.22,38.87 51.95,36.6 43.15,36.6 42.78,36.22 41.89,36.22 41.23,35.57 40.9,35.57 40.7,35.77 39.66,35.77 39.07,35.19 v2(39.07,35.16)
I2S2_MCK: length 96.4
  TOP w0.089: v1(14.97,35.69) 14.97,35.9 16.96,37.9 16.96,41.05 17.78,41.87 19.32,41.87 20.65,40.53 23.58,40.53 26.88,37.23 30.18,37.23 30.57,36.84 35.31,36.84 v2(35.62,37.14)
  IN1 w0.076: v1(14.97,35.69) 14.59,35.31 14.59,34.52 13.16,33.09 13.16,31.99 12.89,31.73 11.9,31.73 v1(11.84,31.67)
  IN2 w0.058: v2(35.62,37.14) 35.8,37.32 35.8,40.51 36.41,41.12 36.41,41.52 37.98,43.1 38.92,43.1 39.5,43.68 41.78,43.68 42.2,43.25 45.68,43.25 46.5,44.07 55.76,44.07 56.93,45.24 59.84,45.24 60.7,46.1 64.05,46.1 65.16,47.22 66.86,47.22 67.78,48.14 68.33,48.14 69.18,48.99 73.35,48.99 74.5,47.84 74.5,46.72 74.76,46.46 74.76,42.7 76.78,40.68 76.78,39.46 77.54,38.71 78.5,38.71 80.27,36.94 80.53,36.94 80.83,36.63 82.48,36.63 82.61,36.76 v8(82.64,36.76)
I2S3_DO: length 162.1
  TOP w0.075: U1001.AG1 80.26,33.19 80.26,32.6 80.29,32.57 80.29,32.44
  TOP w0.089: U6502.B1 32.4,10.65 32.72,10.98 v1(32.72,11.06) ; v1(76.88,31.36) 76.96,31.44 77.54,31.44 77.55,31.43 77.82,31.43 78.05,31.65 78.85,31.65 79.15,31.95 79.8,31.95 80.29,32.44
  IN1 w0.076: v2(25.61,20.3) 25.61,29.34 25.76,29.5 25.76,30.31 25.38,30.69 25.38,34.25 26.92,35.78 26.92,36.42 29.61,39.11 29.61,44.15 31.04,45.58 34.74,45.58 37.32,43.01 37.32,40.98 38.46,39.83 42.48,39.83 43.87,41.23 43.87,41.48 46.52,44.13 49.41,44.13 55.99,37.55 57.11,37.55 58.82,35.85 60.36,35.85 60.43,35.77 61.26,35.77 62.1,34.93 65.95,34.93 66.86,35.85 66.86,37.27 67.06,37.47 67.06,37.74 67.27,37.95 71.38,37.95 71.9,38.47 72.81,38.47 73.31,37.96 73.31,35.42 74.56,34.17 75.88,34.17 76.31,33.74 76.31,32.06 76.88,31.49 v1(76.88,31.36) ; v1(11.84,30.59) 12.17,30.92 12.17,31.12 12.33,31.27 13.19,31.27 13.93,30.54 13.93,30 14.82,29.11 14.82,26.83 13.62,25.63 13.62,25.25 13.8,25.08 14.28,25.08 14.56,25.36 16.42,25.36 17.03,24.75 17.03,21.8 15.34,20.11 v2(15.34,18.32) 14.99,17.97 14.99,13.87 19.49,9.38 19.49,6.48 20.94,5.04 24.55,5.04 24.59,4.99 v1(24.64,4.99) 25.16,4.99 25.66,5.49 27.49,5.49 30.89,8.9 30.89,11.39 31.1,11.6 32.18,11.6 v1(32.72,11.06)
  IN2 w0.058: v2(25.61,20.3) 25.61,20.19 24.26,18.84 24.26,17.57 23.82,17.13 21.93,17.13 20.79,18.27 19.31,18.27 18.75,18.83 15.85,18.83 v2(15.34,18.32)
I2S3_TDM_BCK: length 203
  TOP w0.089: v2(25.13,30.08) 25.13,31.27 25.26,31.4 U6563.10
  IN1 w0.06: v7(90.24,34.76) 90.43,34.76 90.57,34.62 90.57,34.45 90.87,34.14 91.17,34.14 91.62,33.7 91.62,32.86 91.35,32.59
  IN1 w0.076: 91.35,32.59 91.35,32.44 91.58,32.21 91.58,31.86 91.78,31.65 91.78,31.06 91.91,30.93 91.91,29.81 93.1,28.62 93.1,27.72 93.79,27.03 94.19,27.03 94.38,26.84 94.89,26.84 96.07,25.66 96.87,25.66 97.63,24.9 102.85,24.9 103.13,24.62 v2(104,24.62)
  IN2 w0.058: v3(128.02,42.68) 128,42.68 127.36,42.04 125.71,42.04 123.32,39.65 123.32,35.71 121.9,34.29 121.9,33.91 120.83,32.83 120.83,26.74 120.63,26.55 120.1,26.55 119.74,26.91 116.08,26.91 115.81,27.18 111.51,27.18 110.79,26.46 109.33,26.46 108.87,26 107.66,26 107.56,25.9 105.28,25.9 v2(104,24.62) ; v2(25.13,30.08) 25.3,29.9 29.07,29.9 30.04,30.88 30.04,31.62 31.43,33 32.98,33 33.5,33.52 33.78,33.52 34.08,33.83 34.08,33.98 34.42,34.31 34.42,35.66 34.88,36.12 35.8,36.12 36.13,36.46 36.13,37.01 36.53,37.42 36.53,40.52 36.69,40.67 36.69,41.5 38.07,42.89 39.01,42.89 39.59,43.47 41.69,43.47 42.12,43.04 45.77,43.04 46.59,43.86 55.85,43.86 57.02,45.03 59.92,45.03 60.79,45.89 64.14,45.89 65.07,46.82 65.69,46.82 v3(65.82,46.69)
  IN3 w0.102: v3(128.02,42.68) 128.02,43.29 127.57,43.74 127.57,46.44 126.93,47.07 126.93,48.73 125.94,49.72 124.95,49.72 123.99,50.68 123.99,54.57 123.03,55.52 121.8,55.52 120.96,56.36 120.96,57.8 119.57,59.2 119.57,60.76 115.93,64.4 77.11,64.4 72.67,59.95 71.55,59.95 69.99,58.39 69.99,53.91 68.74,52.66 68.74,51.07 66.4,48.74 66.4,47.4 65.82,46.82 v3(65.82,46.69)
I2S3_TDM_D0: length 85
  TOP w0.089: v2(26.35,29.17) 26.71,28.81 R90818.1
  IN1 w0.076: v1(25.82,32.4) 26.25,31.97 26.25,31.29 26.4,31.13 26.4,29.22 v2(26.35,29.17)
  IN2 w0.058: v2(26.35,29.17) 27.04,28.48 30.15,28.48 31.96,30.28 37.17,30.28 38.51,31.63 39.69,31.63 40.83,32.76 42.62,32.76 42.96,32.42 44.12,32.42 45.01,33.31 46.6,33.31 47.46,34.17 53.07,34.17 53.32,33.92 59.83,33.92 60.45,33.29 62.49,33.29 64.02,31.77 66.07,31.77 66.7,32.4 67.35,32.4 67.93,32.98 69.35,32.98 69.94,32.4 72.18,32.4 73.61,30.97 73.61,29.71 75.73,27.58 76.61,27.58 80.03,24.16 83.26,24.16 83.67,24.58 85.42,24.58 85.77,24.22 86.39,24.22 86.84,24.67 86.84,26.97 87.55,27.68 87.55,29.1 88.1,29.64 88.1,29.95 88.93,30.78 88.93,32.52 88.84,32.62 88.84,34.33 88.64,34.53 v8(88.64,34.76)
I2S3_TDM_D1: length 87.5
  TOP w0.089: v2(26.86,29.22) 26.96,29.22 27.37,28.81 R90813.1
  IN1 w0.06: v7(88.64,33.56) 88.64,34.07 88.83,34.27 89.16,34.27 89.26,34.17 89.26,33.74 89.24,33.71 89.24,33.35 88.95,33.07 88.95,30.41 89.33,30.04
  IN1 w0.076: v1(25.82,32.9) 25.91,32.9 27.24,31.57 27.24,30.44 26.86,30.05 v2(26.86,29.22) ; v2(56.61,34.66) 57.27,34.66 57.74,34.19 59.62,34.19 59.72,34.09 60.51,34.09 60.71,33.89 61.31,33.89 61.68,33.52 61.84,33.52 64.23,31.12 71,31.12 71.46,30.66 72.73,30.66 73.21,30.18 73.21,28.91 75.59,26.54 76.75,26.54 79.66,23.63 83.68,23.63 83.93,23.88 86.57,23.88 86.98,24.29 86.98,24.91 87.3,25.23 88.43,25.23 89,25.8 89,27.57 88.88,27.68 88.88,28.84 89.39,29.34 89.39,29.98 89.33,30.04
  IN2 w0.058: v2(26.86,29.22) 27.39,28.69 29.98,28.69 31.81,30.51 37.1,30.51 38.42,31.84 39.61,31.84 40.74,32.97 42.71,32.97 43.04,32.63 44.03,32.63 44.92,33.52 46.51,33.52 47.37,34.38 53.25,34.38 53.83,34.96 56.32,34.96 v2(56.61,34.66)
I2S3_TDM_D2: length 86
  TOP w0.089: R90814.1 28.02,29.09 27.82,29.09 27.54,29.37 v2(27.29,29.37)
  IN1 w0.076: v2(27.29,29.37) 27.29,30.11 27.53,30.35 27.53,31.69 v1(25.82,33.4)
  IN2 w0.058: v8(88.24,34.76) 88.72,34.28 88.72,30.87 87.87,30.02 87.87,29.71 87.34,29.19 87.34,27.78 86.63,27.07 86.63,24.76 86.3,24.43 85.86,24.43 85.5,24.79 83.59,24.79 83.19,24.39 80.1,24.39 76.69,27.8 75.82,27.8 73.82,29.8 73.82,31.06 72.27,32.61 70.02,32.61 69.44,33.19 67.84,33.19 67.26,32.61 66.61,32.61 65.99,31.98 64.1,31.98 62.58,33.5 60.53,33.5 58.87,35.17 53.56,35.17 52.99,34.6 47.29,34.6 46.43,33.73 43.64,33.73 43.32,33.41 42.49,33.41 42.26,33.18 40.65,33.18 39.52,32.05 38.34,32.05 37.03,30.74 31.68,30.74 29.84,28.9 27.67,28.9 27.29,29.28 v2(27.29,29.37)
I2S3_TDM_D3: length 67.8
  TOP w0.089: R91151.1 28.71,29.17 28.38,29.17 28.08,29.47 v2(27.92,29.47)
  IN1 w0.06: v2(80.48,35.52) 80.48,35.54 81.21,36.28 81.75,36.28 v7(81.83,36.36)
  IN1 w0.076: v1(25.82,33.9) 27.76,31.96 27.76,30.11 27.92,29.95 v2(27.92,29.47)
  IN2 w0.058: v2(80.48,35.52) 80.09,35.9 79.92,35.9 79.74,36.07 79.46,36.07 79.03,35.64 78.11,35.64 77.3,36.46 76.56,36.46 73.85,39.17 68.56,39.17 68.09,39.64 62.01,39.64 61.03,38.66 57.46,38.66 57.38,38.58 56.01,38.58 55.29,37.87 53.82,37.87 52.13,36.18 43.33,36.18 42.95,35.8 42.15,35.8 41.82,35.48 41.82,34.59 41.6,34.37 39.94,34.37 38.79,33.23 37.07,33.23 36.99,33.15 33.67,33.15 32.26,31.74 31.72,31.74 29.42,29.44 27.95,29.44 v2(27.92,29.47)
I2S3_TDM_LRCK: length 86.2
  IN1 w0.06: v7(89.43,33.56) 89.46,33.53 89.46,33.31 89.07,32.92 89.07,30.55 89.39,30.23
  IN1 w0.076: v1(25.82,31.9) 25.82,31.37 26.17,31.02 26.17,29.57 26.02,29.42 v2(26.02,28.81) ; v2(44.96,34.64) 45.45,34.64 46.07,34.02 57.54,34.02 57.59,33.97 59.52,33.97 59.62,33.86 60.41,33.86 60.61,33.66 61.2,33.66 61.58,33.29 61.74,33.29 64.14,30.89 70.9,30.89 71.36,30.44 72.6,30.44 72.98,30.05 72.98,28.81 75.75,26.05 76.92,26.05 79.56,23.4 84.06,23.4 84.22,23.56 86.91,23.56 87.26,23.91 87.26,24.87 87.39,25 88.25,25 88.48,24.77 89.11,24.77 89.26,24.92 89.26,27.9 89.2,27.96 89.2,28.83 89.62,29.24 89.62,29.7 89.62,29.7 89.62,30 89.39,30.23
  IN2 w0.058: v2(44.96,34.64) 44.75,34.42 43.43,34.42 43.06,34.04 42.23,34.04 42,33.82 40.15,33.82 39.02,32.69 37.67,32.69 37.08,32.1 36.81,32.1 35.98,31.27 32.44,31.27 32.17,31.53 31.84,31.53 29.42,29.11 27.75,29.11 27.59,29.27 27.59,29.5 27.42,29.68 26.25,29.68 26.02,29.44 v2(26.02,28.81)
I2S5_BCK: length 107.3
  TOP w0.089: v1(79.23,37.6) 79.61,37.98 79.61,39.63 79.35,39.89 78.7,39.89 TP9071.1 77.58,41.01 77.58,41.74 v1(77.15,42.17)
  IN1 w0.06: 80.25,36.29 81,36.29 81.11,36.4 81.56,36.4 81.73,36.56 82.03,36.56 v7(82.24,36.76)
  IN1 w0.076: v1(79.23,37.6) 79.56,37.27 79.56,36.81 80.08,36.29 80.25,36.29 ; v1(77.15,42.17) 76.92,42.4 75.32,42.4 71.89,45.83 71.89,52.15 v2(72.09,52.36)
  IN2 w0.058: v2(72.09,52.36) 71.97,52.47 71.97,57.51 72.16,57.7 72.16,59.29 75.29,62.41 75.29,63.46 77.29,65.46 117.28,65.46 118.44,64.31 123.22,64.31 123.96,65.04 126.19,65.04 126.58,64.65 127.8,64.65 127.96,64.49 129.83,64.49 130.35,63.96 130.87,63.96 v3(131.3,64.4)
  IN4 w0.058: v3(131.3,64.4) 131.5,64.19 v5(131.5,64.04)
  BOTTOM w0.089: U1007.61 141.89,60.28 140.02,62.15 133.24,62.15 131.5,63.89 v5(131.5,64.04)
I2S5_DO: length 118.4
  TOP w0.075: 80.4,32.93 U1001.AH1
  TOP w0.089: 80.4,32.93 80.4,32.66 80.58,32.48 v2(80.58,32.41) 80.5,32.33 80.5,32.31 79.52,31.32 TP9070.1
  IN2 w0.058: v3(71.43,51.49) 72.53,51.49 73.14,52.11 73.14,52.98 72.61,53.51 72.61,57.24 72.8,57.43 72.8,59.03 75.93,62.16 75.93,63.16 77.6,64.83 117.02,64.83 118.17,63.67 122.15,63.67 122.46,63.36 130.06,63.36 130.2,63.22 131.77,63.22 132.7,62.28 139.28,62.28 v2(140.8,60.76) 140.8,60.21 v3(140.89,60.12) ; v2(80.58,32.41) 80.09,32.9 75.8,32.9 75.17,33.53 75.17,35.54 73.87,36.84 71.89,36.84 71.15,37.58 67.64,37.58 v3(67.42,37.8)
  IN3 w0.102: v3(71.43,51.49) 71.38,51.44 71.38,50.81 68.59,48.01 68.03,48.01 67.32,47.31 67.32,46.76 68.03,46.06 68.03,44.74 68.13,44.64 68.13,43.59 67.6,43.06 67.6,41.69 67.39,41.48 67.39,39.91 67.32,39.83 67.32,37.9 v3(67.42,37.8)
  IN4 w0.058: v3(140.89,60.12) v5(140.89,59.76)
I2S5_LRCK: length 107.9
  IN2 w0.058: v3(71.1,54.01) 70.87,54.24 70.87,57 71.74,57.87 71.74,59.46 74.86,62.59 74.86,63.64 77.11,65.89 117.45,65.89 118.61,64.73 123.05,64.73 123.78,65.46 126.11,65.46 126.57,65.92 127.2,65.92 128.18,64.93 130.16,64.93 v3(130.21,64.98) ; v8(82.64,35.96) 82.07,35.96 81.86,36.17 80.68,36.17 80.37,36.48 80.12,36.48 79.53,37.07 v2(79.24,37.07) 78.2,38.11 77.48,38.11 76.18,39.4 76.18,40.52 74.34,42.36 74.34,46.26 72.87,47.73 v3(71.86,47.73)
  IN3 w0.102: v3(71.86,47.73) 71.86,47.76 71.97,47.86 71.97,53.35 71.31,54.01 v3(71.1,54.01)
  IN4 w0.058: v3(130.21,64.98) v5(130.21,64.65)
  BOTTOM w0.089: U1007.58 140.39,59.72 140.39,60.89 139.77,61.52 133.01,61.52 130.79,63.73 130.79,64.06 v5(130.21,64.65)
ISL9238C_BGATE: length 51.6
  TOP w0.178: U6.32 122.39,30.99 122.03,30.63 v6(122.03,30.51)
  TOP w0.508: v6(96.88,11.99) 97.31,11.99 99.17,10.13 99.17,9.4 99.93,8.64 112.88,8.64 113.44,8.08 117.51,8.08 118.3,8.88 119.81,8.88 v6(120.36,8.32)
  IN4 w0.508: v6(122.03,30.51) 122.27,30.51 122.7,30.09 122.7,29.53 122.28,29.12 122.28,19.75 119.87,17.33 119.87,13.06 120.51,12.42 120.51,10.17 120.36,10.02 v6(120.36,8.32)
  BOTTOM w0.254: NC63.1 v6(96.88,11.99)
ISL9238C_CSON: length 40.1
  TOP w0.178: 122.96,29.85 122.97,29.84 123.16,29.84 123.3,29.98 U6.1
  TOP w0.203: v6(119.44,29.24) 119.64,29.04 120.27,29.04 120.46,28.85 121.84,28.85 122.85,29.85 122.96,29.85
  IN2 w0.203: v3(101.63,15.86) 101.98,15.51 101.98,14.76 102.65,14.09 105.41,14.09 105.6,13.9 113.26,13.9 114.06,13.09 v3(114.06,12.94)
  IN3 w0.203: v3(118.62,26.47) 118.62,26.39 118.16,25.93 118.16,20.89 118.82,20.22 118.82,15.8 116.65,13.63 116.36,13.63 116.12,13.39 114.51,13.39 v3(114.06,12.94)
  IN4 w0.203: v3(118.62,26.47) 118.34,26.76 v5(118.34,26.8) ; v3(101.63,15.86) 101.63,16.31 v5(101.71,16.39)
  BOTTOM w0.203: v6(119.44,29.24) 119.37,29.24 118.79,28.66 118.79,28.03 C10496.1 118.34,27.58 v5(118.34,26.8)
ISL9238C_CSOP: length 40.6
  TOP w0.203: v6(119.39,28.53) 119.54,28.68 120.12,28.68 120.31,28.5 121.99,28.5 122.99,29.5 123.3,29.5 123.7,29.9 U6.2
  IN2 w0.203: v3(114.68,12.83) 114.68,12.98 113.4,14.26 105.75,14.26 105.56,14.45 102.79,14.45 102.34,14.9 102.34,15.54 v3(102.65,15.86)
  IN3 w0.203: v3(119.4,26.47) 119.34,26.47 118.86,26 118.8,26 118.56,25.76 118.56,21.06 119.23,20.39 119.23,15.63 116.82,13.22 116.52,13.22 116.29,12.98 114.83,12.98 v3(114.68,12.83)
  IN4 w0.203: v5(119.12,26.8) 119.12,26.76 v3(119.4,26.47) ; v3(102.65,15.86) 102.65,16.34 v5(102.6,16.39)
  BOTTOM w0.203: v5(119.12,26.8) 119.12,27.12 119.6,27.6 C10495.1 119.23,27.8 119.15,27.89 119.15,28.29 v6(119.39,28.53)
ISL9238C_LDO_5V: length 18.2
  TOP w0.178: v1(125.14,36.45) 125.7,35.89 U6.18
  IN1 w0.254: v1(131.76,27.16) 131.76,27.26 129.27,29.75 129.27,32.77 130.49,33.99 130.49,36.05 130.09,36.45 v1(125.14,36.45)
ISL9238C_LG1: length 6.9
  IN2 w0.762: v6(130.36,29.62) 130.36,30.74 131.78,32.16 131.78,35.46 v11(132.14,35.82)
ISL9238C_LG2:
  vias: v6(129.78,28.4)
ISL9238C_PH1:
  vias: v6(131.43,30.38)
ISL9238C_PH2:
  vias: v6(127.24,26.72)
ISL9238C_UG1: length 5.7
  IN2 w0.762: v6(130.28,32.26) 129.45,33.1 129.45,33.79 127.47,35.77 v6(126.4,35.77)
ISL9238C_VDDP: length 7.1
  TOP w0.203: U6.8 126.32,30.61 126.98,30.61 128.58,29.01 130.14,29.01 C436.2 R707.1
IT6505_CK: length 2.5
  IN2 w0.058: v2(37.36,20.94) 37.31,20.94 v3(37.08,21.17)
  IN4 w0.058: v3(37.08,21.17) 37.17,21.17 37.41,21.4 37.54,21.4 37.88,21.75 v5(37.91,21.75) 38.01,21.75 v5(38.67,21.09)
IT6505_CK_R: length 5.4
  TOP w0.089: v1(34.7,22.79) 34.55,22.79 34.49,22.72 U1.80
  IN1 w0.076: v1(34.7,22.79) 34.78,22.79 35.62,21.95 35.62,21.32 v2(35.59,21.29)
  IN2 w0.058: v3(35.9,21.14) 35.9,21.16 35.86,21.2 35.86,21.23 35.8,21.29 v2(35.59,21.29)
  IN4 w0.058: v5(37.5,21.75) 37.26,21.51 36.77,21.51 36.76,21.52 36.33,21.52 35.95,21.14 v3(35.9,21.14)
IT6505_D0: length 5
  TOP w0.089: U1.76 34.17,21.12 v1(34.32,21.27)
  IN1 w0.076: v1(34.32,21.27) 34.55,21.04 35.06,21.04 35.49,20.61 37.04,20.61 v2(37.36,20.29)
  IN2 w0.058: v2(37.36,20.29) 37.26,20.29 v3(37.08,20.47)
  IN4 w0.058: v5(37.4,20.3) 37.23,20.47 v3(37.08,20.47)
IT6505_D1: length 5.1
  TOP w0.089: v1(34.32,20.81) 34.24,20.72 U1.75
  IN1 w0.076: v1(34.32,20.81) 34.95,20.81 35.47,20.29 v2(36.69,20.29)
  IN2 w0.058: v3(36.45,20.52) v2(36.69,20.29)
  IN4 w0.058: v3(36.45,20.52) 36.91,20.06 v5(36.94,20.06)
  BOTTOM w0.089: v5(36.94,20.06) 36.94,19.92 37.27,19.59 R90821.2
IT6505_D2: length 6.8
  TOP w0.089: U1.74 34.22,20.32 34.25,20.35 v1(34.32,20.35)
  IN1 w0.076: v2(37.39,19.64) 37.05,19.97 35.39,19.97 35.01,20.35 v1(34.32,20.35)
  IN2 w0.058: v3(37.04,19.64) 37.38,19.64 v2(37.39,19.64)
  IN4 w0.058: v3(37.04,19.64) 37.09,19.59 38.31,19.59 38.51,19.79 v5(38.62,19.79)
  BOTTOM w0.089: R90820.2 38.67,19.95 38.62,19.89 v5(38.62,19.79)
IT6505_D3: length 6
  TOP w0.089: v1(34.32,19.89) 34.3,19.92 U1.73
  IN1 w0.076: v1(34.32,19.89) 34.55,19.89 34.81,19.64 v2(36.61,19.64)
  IN2 w0.058: v3(36.28,19.54) 36.51,19.54 v2(36.61,19.64)
  IN4 w0.058: v3(36.28,19.54) 36.53,19.28 37.3,19.28 37.37,19.36 v5(38.57,19.36)
IT6505_D4: length 6
  TOP w0.089: v1(34.49,19.45) 34.42,19.52 U1.72
  IN1 w0.076: v2(36.61,18.98) 35,18.98 34.54,19.45 v1(34.49,19.45)
  IN2 w0.058: v3(36.43,18.7) 36.43,18.8 v2(36.61,18.98)
  IN4 w0.058: v3(36.43,18.7) 36.57,18.56 37.33,18.56 37.57,18.32 37.83,18.32 38.21,18.7 v5(38.49,18.7)
IT6505_D5: length 4.9
  TOP w0.089: v1(34.63,18.9) 34.41,19.12 U1.71
  IN1 w0.076: v2(37.36,18.98) 37.05,18.67 34.94,18.67 34.7,18.9 v1(34.63,18.9)
  IN2 w0.058: v2(37.36,18.98) 37.28,18.9 v3(37.04,18.9)
  IN4 w0.058: v5(37.42,19.01) 37.14,19.01 v3(37.04,18.9)
IT6505_D6: length 7.6
  TOP w0.089: v1(34.7,18.45) 34.63,18.45 34.35,18.72 U1.70
  IN1 w0.076: v2(36.66,18.33) 34.82,18.33 v1(34.7,18.45)
  IN2 w0.058: v2(36.66,18.33) 36.45,18.12 v3(36.45,18.07)
  IN4 w0.058: v3(36.45,18.07) 36.75,18.07 36.96,17.87 37.27,17.87 37.35,17.79 37.96,17.79 38.26,18.09 v5(38.29,18.09)
  BOTTOM w0.089: v5(38.29,18.09) 39.02,18.09 39.38,18.45 39.38,18.57 39.55,18.75 R90824.2
IT6505_D7: length 4.9
  TOP w0.089: v1(34.32,18.29) 34.29,18.32 U1.69
  IN1 w0.076: v1(34.32,18.29) 34.52,18.1 34.96,18.1 35.06,18 37.08,18 v2(37.41,18.33)
  IN2 w0.058: v2(37.41,18.33) 37.3,18.22 v3(37.09,18.22)
  IN4 w0.058: v3(37.09,18.22) 37.3,18.22 v5(37.42,18.09)
IT6505_D8: length 10
  TOP w0.089: U1.61 v1(30.63,15.78)
  IN1 w0.076: v5(36.71,17.69) 36.61,17.58 35.29,17.58 32.96,15.25 30.84,15.25 30.63,15.46 v1(30.63,15.78)
  IN2 w0.058: v5(36.71,17.69) v3(36.43,17.41)
  IN4 w0.058: v5(36.71,17.68) 36.64,17.68 36.43,17.48 v3(36.43,17.41)
  BOTTOM w0.089: R90830.2 36.97,17.43 v5(36.71,17.68)
IT6505_D9: length 12
  TOP w0.089: U1.60 30.23,15.8 v1(30.21,15.78)
  IN1 w0.076: v2(37.36,17.69) 37.03,17.35 35.42,17.35 33.06,14.99 30.72,14.99 30.21,15.5 v1(30.21,15.78)
  IN2 w0.058: v3(37.02,17.37) 37.34,17.69 v2(37.36,17.69)
  IN4 w0.058: v3(37.02,17.37) 37.36,17.04 37.59,17.04 37.65,16.98 v5(37.65,16.96)
  BOTTOM w0.089: v5(37.65,16.96) 37.73,17.04 38.27,17.04 38.44,17.2 R90829.2
IT6505_D10: length 14.2
  TOP w0.089: U1.59 v1(29.83,15.48)
  IN1 w0.076: v1(29.83,15.48) 30.56,14.75 33.2,14.75 35.48,17.04 v2(36.71,17.04)
  IN2 w0.058: v2(36.71,17.04) v3(36.47,16.8)
  IN4 w0.058: v5(39.74,16.41) 39.74,15.99 39.27,15.53 37.37,15.53 36.47,16.42 v3(36.47,16.8)
IT6505_D11: length 11.5
  TOP w0.089: v1(29.43,15.78) U1.58
  IN1 w0.076: v1(29.43,15.78) 29.43,15.26 30.18,14.51 33.33,14.51 35.52,16.69 36.57,16.69 36.58,16.7 36.84,16.7 36.85,16.69 37.02,16.69 v2(37.36,17.04)
  IN2 w0.058: v2(37.36,17.04) 37.33,17.04 v3(37.09,16.8)
  IN4 w0.058: v3(37.09,16.8) 36.89,16.59 v5(36.89,16.39)
IT6505_DE: length 5.3
  TOP w0.089: U1.78 34.12,21.92 34.48,21.57 v1(34.63,21.57)
  IN1 w0.076: v1(34.63,21.57) 34.86,21.34 35.09,21.34 35.49,20.94 v2(36.71,20.94)
  IN2 w0.058: v3(36.47,21.18) v2(36.71,20.94)
  IN4 w0.058: v5(37.52,21.14) 37.19,20.81 36.84,20.81 v3(36.47,21.18)
IT6505_HPD_L: length 4.4
  IN1 w0.06: 80.25,36.52 81.5,36.52 81.74,36.76 v7(81.83,36.76)
  IN1 w0.076: 80.25,36.52 80.18,36.52 79.81,36.89 79.81,37.81 79.56,38.06 v1(78.75,38.06)
IT6505_HSYNC: length 6.7
  TOP w0.089: U1.81 34.28,23.12 34.32,23.17 v1(34.4,23.17)
  IN1 w0.076: v1(34.4,23.17) 34.86,23.17 36.44,21.59 v2(36.71,21.59)
  IN2 w0.058: v3(36.45,21.87) 36.71,21.61 v2(36.71,21.59)
  IN4 w0.058: v3(36.45,21.87) 36.79,22.21 38.34,22.21 v5(38.65,22.51)
IT6505_I2S_BCK: length 5.8
  TOP w0.089: R91032.1 R91152.2 25.95,29.63 26.12,29.8 28.68,29.8 29.27,30.38 U6563.14
IT6505_I2S_BCK_R: length 2.2
  TOP w0.089: U1.17 26.23,27.57 25.45,28.36 R91032.2
IT6505_I2S_D0: length 7
  TOP w0.089: U1.15 27.03,28.11 v1(26.78,28.36)
  IN1 w0.076: v1(29.27,31.9) 29.58,31.59 29.58,30.28 28.2,28.9 28.05,28.9 27.9,28.76 27.49,28.76 27.09,28.36 v1(26.78,28.36)
IT6505_I2S_D1: length 7.1
  TOP w0.089: v1(27.54,28.36) 27.43,28.25 U1.14
  IN1 w0.076: v1(29.27,32.4) 29.89,31.78 29.89,30.21 28.34,28.67 28.14,28.67 27.82,28.36 v1(27.54,28.36)
IT6505_I2S_D2: length 7.6
  TOP w0.089: v1(28.3,28.36) 27.83,27.88 U1.13
  IN1 w0.076: v1(28.3,28.36) 28.62,28.36 30.13,29.87 30.13,32.04 v1(29.27,32.9)
IT6505_I2S_D3: length 8.1
  TOP w0.089: U1.12 28.23,27.88 28.32,27.97 28.68,27.97 v1(29.07,28.36)
  IN1 w0.076: v1(29.27,33.4) 30.36,32.31 30.36,29.65 v1(29.07,28.36)
IT6505_I2S_LRCK: length 6.9
  TOP w0.089: U1.16 26.63,27.74 v1(26.02,28.36)
  IN1 w0.076: v1(29.27,31.4) 29.27,30.29 28.1,29.13 27.95,29.13 27.81,28.99 27.39,28.99 27.08,28.68 26.6,28.68 26.28,28.36 v1(26.02,28.36)
IT6505_INT_ODL: length 136.6
  TOP w0.089: R90735.1 25.35,14.92 25.35,14.76 25.54,14.56 32.88,14.56 35.47,17.15 35.47,23.3 36.66,24.49 43.68,24.49 44.74,25.55 44.74,25.56 45.82,26.64 45.82,29.87 45.6,30.08 v2(45.6,30.16)
  IN1 w0.076: v2(96.35,41.71) 96.57,41.5 96.57,40.59 97.56,39.6 97.56,37.23 98.17,36.61 v2(98.17,35.92)
  IN2 w0.058: v2(45.6,30.16) 45.3,30.16 v3(45.23,30.22) ; v2(98.17,35.92) 98.17,35.36 97.57,34.75 97.57,31.96 97.66,31.87 97.66,30.17 98.36,29.47 98.36,28.39 98.88,27.87 98.88,26.94 99.75,26.07 100.58,26.07 100.95,25.7 100.95,25.03 v3(100.82,24.9)
  IN2 w0.06: 91.96,40.47 91.77,40.47 91.24,39.94 89.62,39.94 89.47,39.79 89.26,39.79 v8(89.04,39.56)
  IN2 w0.075: v2(96.35,41.71) 96.15,41.51 95.99,41.51 95.61,41.13 95.13,41.13 94.9,41.36 94.19,41.36 93.94,41.1 93.79,41.1 93.16,40.47 91.96,40.47
  IN3 w0.102: v3(45.23,30.22) 45.92,29.54 46.63,29.54 49.51,26.65 58.95,26.65 61.16,28.86 61.27,28.86 61.55,29.14 61.55,29.5 61.2,29.85 61.2,32.49 63.53,34.83 65.9,34.83 66.81,33.92 66.81,28.79 66.81,28.78 70.04,28.78 70.8,28.03 70.8,27.29 78.32,19.76 86.87,19.76 87.78,20.68 91.14,20.68 92.31,21.84 97.93,21.84 100.82,24.74 v3(100.82,24.9)
IT6505_INT_ODL_R: length 2.5
  TOP w0.089: R91298.2 R90735.2 25.95,15.42 26.23,15.7 U1.50
IT6505_RST: length 77.1
  IN2 w0.058: v3(34.53,33.79) 34.63,33.89 34.63,35.46 35.08,35.91 36.5,35.91 36.97,36.38 36.97,40.42 36.91,40.47 36.91,41.41 38.18,42.68 39.1,42.68 39.66,43.24 41.62,43.24 42.03,42.83 45.86,42.83 46.67,43.65 55.94,43.65 57.11,44.82 60.01,44.82 60.88,45.68 64.23,45.68 64.78,46.23 66.18,46.23 67.85,47.91 68.4,47.91 69.27,48.78 73.23,48.78 74.29,47.72 74.29,46.64 74.55,46.37 74.55,42.53 76.44,40.65 76.44,39.5 77.45,38.49 78.42,38.49 80.2,36.71 80.45,36.71 80.75,36.4 82.59,36.4 v8(82.64,36.36)
  IN4 w0.058: v3(34.53,33.79) v5(34.53,33.41)
  BOTTOM w0.089: v5(34.53,33.41) 33.26,32.14 30.98,32.14 27.54,28.7 Q2.2
IT6505_RST_L: length 3.9
  TOP w0.203: U1.21 24.63,27.61 v2(24.6,27.64)
  IN2 w0.203: v3(25.03,28.19) 24.99,28.19 24.63,27.83 24.63,27.67 v2(24.6,27.64) 24.34,27.37 v3(24.34,26.88)
  IN4 w0.203: v5(24.62,28.19) v3(25.03,28.19) 25.7,28.19 v5(25.71,28.2) ; v3(24.34,26.88) v5(24.34,26.55)
IT6505_VSYNC: length 6.8
  TOP w0.089: v1(34.53,23.63) 34.42,23.52 U1.82
  IN1 w0.076: v1(34.53,23.63) 34.86,23.63 36.58,21.9 37.05,21.9 v2(37.36,21.59)
  IN2 w0.058: v3(37.07,21.85) 37.34,21.59 v2(37.36,21.59)
  IN4 w0.058: v3(37.07,21.85) 37.24,22.03 38.57,22.03 v5(38.65,21.95)
JACKDET_L: length 4.6
  TOP w0.127: U6504.D16 12.3,33.14 v1(12.3,34.68)
  IN1 w0.127: v1(12.3,34.68) 10.26,34.68 v1(9.63,35.3)
KB_INT_ODL: length 46.1
  TOP w0.089: v2(140.1,19.77) U6559.32 ; v2(120.51,48.27) 120.3,48.47 R91187.1
  IN2 w0.058: v3(140.47,19.77) v2(140.1,19.77) ; v2(120.51,48.27) 120.51,48.06 121.03,47.54 121.18,47.54 v3(121.23,47.49)
  IN3 w0.102: v3(140.47,19.77) 140.47,21.95 141.61,23.09 141.61,34.91 138.79,37.73 135.65,37.73 135.14,38.23 133.57,38.23 130.04,41.76 124.85,41.76 124.21,42.4 124.21,43.74 123.78,44.18 122.31,44.18 121.9,44.58 121.9,46.44 121.23,47.11 v3(121.23,47.49)
KSI0: length 28
  TOP w0.089: U6559.18 144.38,15.68 145.01,15.05 145.17,15.05 145.61,14.61 v2(145.78,14.61)
  IN2 w0.058: v3(135.49,9.32) 135.64,9.32 v2(136,9.69) 136.48,10.17 140.32,10.17 140.85,10.7 143.01,10.7 144.59,12.27 144.59,12.91 145.45,13.77 145.45,14.28 v2(145.78,14.61)
  IN4 w0.058: v5(135.49,9.66) v3(135.49,9.32)
  BOTTOM w0.089: v5(135.49,9.66) 135.44,9.71 CON7102.13 135.44,15.93 132.42,18.95 CON9105.13
KSI1: length 36.1
  TOP w0.089: v2(144.89,15.68) 145.11,15.89 145.11,16.54 144.88,16.76 144.55,16.76 144.27,16.48 U6559.20
  IN2 w0.058: v2(144.89,15.68) 144.69,15.68 142.6,13.6 138.13,13.6 137.2,12.67 136.35,12.67 135.03,11.34 131.16,11.34 130.44,10.63 130.33,10.63 130.12,10.42 129.72,10.42 129.5,10.19 128.25,10.19 128.06,9.99 127.16,9.99 v2(126.86,9.69) 126.5,9.33 v3(126.47,9.33)
  IN4 w0.058: v3(126.47,9.33) 126.45,9.33 126.35,9.43 v5(126.35,9.66)
  BOTTOM w0.089: CON9105.24 123.62,19.24 126.09,16.77 126.09,13.09 126.64,12.54 CON7102.24 126.64,9.95 v5(126.35,9.66)
KSI2: length 106.1
  IN2 w0.058: v3(59.6,8.92) 59.77,8.75 59.94,8.75 60.34,8.35 60.34,8.18 65.62,2.91 68.08,2.91 68.61,3.43 72.84,3.43 74.92,5.51 75.38,5.51 79.49,9.62 80.48,10.04 81.64,10.49 84.78,10.49 85.79,9.48 88.25,9.48 91.22,6.5 120.86,6.5 121.57,7.21 123.63,7.21 124.02,7.61 125.18,7.61 126.24,8.67 130.82,8.67 131.05,8.9 131.58,8.9 v3(132.04,9.35) 132.14,9.45 v2(132.14,9.69)
  IN4 w0.058: v4(58.53,9.79) 58.63,9.79 59.49,8.92 v3(59.6,8.92) ; v3(132.04,9.35) 132.19,9.51 v5(132.19,9.66)
  IN5 w0.076: v5(51.95,14.41) 51.95,14.09 51.62,13.76 51.62,13.08 51.67,13.03 51.67,12.03 52.6,11.11 54.52,11.11 55.48,10.14 58.17,10.14 v4(58.53,9.79)
  BOTTOM w0.089: CON9105.17 129.22,19.99 132.24,16.97 CON7102.17 132.24,9.71 v5(132.19,9.66) ; R3001.2 52.12,14.59 v5(51.95,14.41)
KSI3: length 109.7
  TOP w0.089: v2(129.79,11.19) 129.88,11.19 130.38,10.69 133.64,10.69 133.96,10.37 133.96,9.81 133.83,9.69 D2725.1 v2(133.51,9.69) R90858.2
  IN2 w0.058: v3(133.08,9.32) 133.15,9.32 v2(133.51,9.69) ; v3(61.6,8.39) 61.6,7.82 65.88,3.54 67.72,3.54 69.01,4.83 72.43,4.83 73.9,6.31 75.28,6.31 79.13,10.15 80.24,10.63 81.52,11.12 85.04,11.12 86.05,10.11 88.51,10.11 91.49,7.13 120.59,7.13 122.31,8.85 124.71,8.85 125.19,9.34 125.19,9.83 125.99,10.63 127.79,10.63 127.99,10.83 129.23,10.83 129.58,11.19 v2(129.79,11.19)
  IN4 w0.058: v3(133.08,9.32) v5(133.08,9.66) ; v4(60.21,9.94) 60.21,9.91 61.6,8.51 v3(61.6,8.39)
  IN5 w0.076: v4(60.21,9.94) 60.21,10.16 59.18,11.18 55.79,11.18 54.95,12.02 53.32,12.02 52.56,12.78 52.56,13.84 v5(52.69,13.96)
  BOTTOM w0.089: CON9105.16 130.02,19.83 132.57,17.28 132.57,13.39 133.04,12.92 CON7102.16 133.04,9.7 v5(133.08,9.66) ; v5(52.69,13.96) 52.69,13.52 52.35,13.18 R3005.1
KSI4: length 37.6
  TOP w0.089: v2(144.64,19.11) 144.18,19.56 142.99,19.56 142.9,19.48 U6559.25
  IN2 w0.058: v3(129.78,9.32) 129.78,9.46 D2729.1 v2(130.06,9.69) 130.28,9.69 130.59,9.99 130.7,9.99 131.38,10.67 135.26,10.67 135.89,11.3 137.45,11.3 138.98,12.83 142.96,12.83 144.93,14.8 145.18,14.8 145.65,15.27 145.65,17.92 144.64,18.93 v2(144.64,19.11)
  IN4 w0.058: v3(129.78,9.32) v5(129.78,9.66)
  BOTTOM w0.089: CON9105.20 126.82,18.2 129.84,15.18 CON7102.20 129.84,9.72 v5(129.78,9.66)
