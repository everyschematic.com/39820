# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PP1800_EC: length 288.1
  TOP w0.152: Q739.5 123.3,42.63 123.24,42.57
  TOP w0.203: 39.22,7.51 38.83,7.91 v2(38.77,7.91) ; 39.22,7.51 R90451.1 ; 39.22,7.51 39.11,7.39 Q8.2 ; v6(120.07,49.69) 119.72,49.33 119.72,44.05 121.6,42.17 122.84,42.17 123.24,42.57 123.24,42.57 ; R619.1 23.91,44.1 v2(23.99,44.02) ; Q793.2 129.09,56.16 v2(128.93,56) ; v2(122.04,48.65) 122.04,48.76 121.26,49.54 R90523.1 R90524.1 ; R90368.1 121.8,47.05 v2(122.16,47.41)
  TOP w0.254: v2(64.45,6.84) 64.07,7.22 64.07,12.29 63.89,12.47 v1(63.89,13.95)
  TOP w0.381: v1(145.45,27.79) 145.37,27.87 Q759.2 144.25,28.12 143.87,28.5 142.91,28.5 142.28,27.87 Q788.2 141.96,28.71 141.58,29.09 140.7,29.09 139.61,30.18 139.61,37.9 137.88,39.63 131.38,39.63 130.39,40.62 v1(130.39,41.15) v1(130.39,41.66)
  IN1 w0.254: v2(24.14,35.36) 24.77,36 24.77,36.33 25.15,36.71 26.27,36.71 29.07,39.5 29.07,44.38 30.84,46.16 34.98,46.16 v6(35.31,46.49)
  IN1 w0.381: v6(130.74,47.71) 130.39,47.35 v1(130.39,41.66) v1(130.39,41.15) ; v1(145.45,27.79) v1(145.45,26.17)
  IN2 w0.203: v2(38.77,7.91) 39.71,7.91 40.09,8.29 40.09,9.56 40.24,9.71 v3(40.24,10.37) ; v2(122.16,47.41) 122.04,47.52 v2(122.04,48.65) ; v3(124.38,56.08) 124.66,56.08 v2(124.82,56.24) ; v3(128.01,54.23) 128.77,54.23 129.14,53.85 v2(129.55,53.85) ; v2(23.99,44.02) 23.83,44.02 22.42,42.62 20.89,42.62 20.71,42.44 20.71,41.18 21.62,40.27 21.62,39.27 20.84,38.5 20.13,38.5 19.26,37.63 v3(19.26,36.68) ; v2(128.93,56) 128.53,55.6 v2(128.13,55.6) 127.98,55.45 v3(127.67,55.45) ; v3(125.33,55.61) 125.78,56.06 v2(125.78,56.23) ; v3(123.1,54.79) 122.97,54.67 v2(122.41,54.67) ; v2(123.55,58.3) 123.3,58.05 123.3,57.66 v6(122.28,56.65) ; v5(123.68,56.53) v3(124.05,56.53) ; v2(24.14,35.36) v3(24.14,34.93)
  IN2 w0.254: v3(34.4,13.98) 38.01,10.37 v3(40.24,10.37) ; v3(64.45,7.17) v2(64.45,6.84)
  IN3 w0.254: v3(34.4,13.98) 34.58,14.15 34.58,22.69 34.3,22.97 34.3,27.49 35.21,28.4 35.21,30.79 36.18,31.76 36.18,32.19 35.11,33.25 32.81,33.25 31.61,34.46 31.61,35.03 30.95,35.69 26.78,35.69 26.53,35.44 24.65,35.44 v3(24.14,34.93) ; v3(40.24,10.37) 43.29,10.37 43.57,10.65 44.33,10.65 44.99,9.99 46.77,9.99 48.32,8.44 52.84,8.44 53.6,7.68 53.86,7.68 54.29,7.25 55.25,7.25 55.61,6.89 58.25,6.89 58.61,6.53 59.24,6.53 59.39,6.69 63.86,6.69 64.35,7.17 v3(64.45,7.17)
  IN4 w0.203: v5(123.5,54.79) v3(123.1,54.79) ; v3(128.01,54.23) 128.09,54.14 v5(128.39,54.14) ; v3(124.38,56.08) v5(124.67,55.78) ; v3(125.33,55.61) v5(125.33,55.12) ; v3(19.26,36.68) 19.26,36.71 19.34,36.79 v5(19.34,37.09) ; v5(40.76,10.42) 40.71,10.37 v3(40.24,10.37) ; v5(24.14,34.52) v3(24.14,34.93) ; v3(124.05,56.53) v5(123.68,56.53) ; v3(127.67,55.45) v5(127.19,55.45)
  IN4 w0.254: v5(68.56,50.93) 68.12,51.38 64.88,51.38 63.93,50.43 63.17,50.43 60.98,48.24 59.27,48.24 58.05,47.02 57.06,47.02 55.84,48.24 43.01,48.24 41.26,46.49 v6(35.31,46.49)
  BOTTOM w0.203: Q783.2 19.49,37.07 18.96,36.54 18.96,34.96 19.1,34.81 ; v5(40.76,10.42) 40.74,10.45 40.74,12.69 41.14,13.1 R90440.2
  BOTTOM w0.254: v5(24.14,34.52) 23.96,34.35 19.95,34.35 Q784.2 19.1,34.81 ; v6(122.28,56.65) 121.67,56.65 121.18,57.14 115.16,57.14 107.25,65.06 76.49,65.06 71.61,60.18 71.61,58.73 70.87,57.99 70.87,53.24 v5(68.56,50.93)
  vias: v1(60.51,14.37) v1(125.34,50.42) v1(125.84,50.42) v1(126.84,49.92) v1(127.24,45.84) v1(128.25,45.84) v1(128.86,45.83) v1(128.86,45.57) v1(129.12,45.83) v1(129.12,45.57) v1(129.37,45.83) v1(129.37,45.57) v6(120.07,50.4) v6(130.44,50.02) v6(130.44,49.31)
PP1800_EC_N: length 90.1
  TOP w0.076: v2(58.5,46.41) 58.35,46.26 58.35,46.13 58.12,45.9 57.56,45.9 56.68,45.01 56.68,44.27 R90543.1 ; NC252.2 119.29,51.92 119.21,52 119.04,52 118.85,52.2 118.85,60.41 119.34,60.91 119.34,61.81 v2(119.11,62.04)
  IN2 w0.076: v2(119.11,62.04) 119.31,62.24 119.31,62.35 119.24,62.42 117.57,62.42 116.38,63.62 78.11,63.62 77.33,62.83 77.33,61.84 74.74,59.24 74.74,51.42 73.39,50.07 68.8,50.07 68.22,50.65 66.72,50.65 66.33,50.26 66.33,49.18 65.82,48.67 63.75,48.67 63.01,47.94 61.03,47.94 59.69,46.59 58.56,46.59 58.5,46.54 v2(58.5,46.41)
PP1800_EC_P: length 90.5
  TOP w0.076: NC251.2 119.29,52.23 119.21,52.15 119.11,52.15 119,52.26 119,60.35 119.49,60.84 119.49,61.86 v2(119.67,62.04) ; v2(58.07,46.44) 58.2,46.31 58.2,46.2 58.06,46.06 57.5,46.06 56.52,45.08 56.52,44.27 R90544.1
  IN2 w0.076: v2(58.07,46.44) 58.38,46.74 59.62,46.74 60.97,48.09 62.95,48.09 63.69,48.82 65.76,48.82 66.18,49.24 66.18,50.32 66.66,50.81 68.28,50.81 68.87,50.22 73.33,50.22 74.58,51.48 74.58,59.31 77.17,61.9 77.17,62.9 78.05,63.77 116.45,63.77 117.64,62.58 119.3,62.58 119.47,62.41 119.47,62.24 v2(119.67,62.04)
PP1800_EMMC: length 5.9
  TOP w0.203: v2(102.85,59.19) 102.85,59.17 102.53,58.86 U18.C6
  IN2 w0.203: v3(102.92,58.87) 102.85,58.94 v2(102.85,59.19) ; v2(107.92,58.41) 108.31,58.41 108.33,58.43 v3(108.36,58.43) ; v2(107.89,57.36) v3(108.22,57.36) ; v3(106.61,57.65) 106.82,57.86 v2(106.89,57.86) ; v2(107.39,57.86) v3(107.39,57.53)
  IN4 w0.203: v3(108.36,58.43) 108.33,58.43 108.21,58.31 v5(107.9,58.31) ; v5(108.56,56.83) 108.56,57.02 v3(108.22,57.36) ; v5(107.44,56.79) 107.44,57.48 v3(107.39,57.53) 107.28,57.65 v3(106.61,57.65) ; v3(102.92,58.87) 102.69,58.63 v5(102.31,58.63)
PP1800_H1: length 55.6
  TOP w0.152: U124.J4 58.29,16.9 58.71,17.33 v2(59.42,17.33) v2(60.18,17.33) ; Q81.2 38.73,5.34 v2(38.34,4.95) 37.85,5.43 37.85,6.03 38.08,6.25 39.53,6.25 39.71,6.43 39.71,7.58 39.86,7.72 R323.1
  IN2 w0.152: v2(38.34,4.95) v3(38.01,4.95)
  IN4 w0.152: v3(38.01,4.95) 38.01,5.31 v5(37.98,5.34) ; v5(41.68,16.25) 41.68,14.8 40.98,14.1 40.14,14.1 v5(39.99,13.95) ; v5(53.81,20) 53.81,19.96 54.18,19.59 55.08,19.59 v3(55.33,19.84)
  BOTTOM w0.152: v5(53.81,20) 53.42,19.61 R90433.1 C10372.1 54.42,18.85 54.72,18.55 54.72,17.89 54.06,17.23 52.74,17.23 52.61,17.35 52.61,19.16 51.82,19.95 50.43,19.95 49.46,20.91 47.68,20.91 47.12,20.35 43.95,20.35 43.59,20.71 42.76,20.71 42.18,20.13 R91277.1 41.77,19.41 41.77,16.34 v5(41.68,16.25) ; Q80.2 v5(39.99,13.95) 37.97,13.95 R90481.1 36.18,13.93 33.75,11.5 33.75,8.4 35.13,7.02 37.4,7.02 37.98,6.44 v5(37.98,5.34)
  vias: v1(51.37,23.17) v1(51.65,23.17) v1(51.98,23.17) v1(55.48,19.41) v1(56.83,22.36) v1(57.74,22.36) v1(60.21,19.06) v1(60.49,22.15) v1(60.46,19.06) v2(51.37,23.17) v2(51.65,23.17) v2(51.98,23.17) v2(55.48,19.41) v2(56.83,22.36) v2(57.74,22.36) v2(60.21,19.06) v2(60.49,22.15) v2(60.46,19.06)
PP1800_H1_N: length 22.8
  TOP w0.076: v1(45.98,32.66) 46.16,32.48 46.16,30.87 46.9,30.13 46.9,28.61 47.96,27.54 47.96,25.98 48.79,25.15 51.27,25.15 52.23,24.19 52.23,24.08 52.15,24.01 NC248.2 ; R90541.1 50.61,35.57 50.61,35.38 50.34,35.11 45.29,35.11 44.86,34.68 44.86,34.33 v1(44.73,34.2)
  IN1 w0.076: v1(45.98,32.66) 46.07,32.75 46.07,33.04 45.95,33.16 45.33,33.16 44.89,33.59 44.89,34.03 v1(44.73,34.2)
PP1800_H1_P: length 22.8
  TOP w0.076: v1(46.41,32.68) 46.31,32.58 46.31,30.93 47.05,30.19 47.05,28.67 48.12,27.6 48.12,26.04 48.85,25.3 51.33,25.3 52.38,24.25 52.38,24.08 52.46,24.01 NC247.2 ; R90542.1 50.76,35.57 50.76,35.31 50.41,34.96 45.35,34.96 45.01,34.62 45.01,34.42 v1(45.21,34.22)
  IN1 w0.076: v1(45.21,34.22) 45.05,34.06 45.05,33.66 45.4,33.31 46.01,33.31 46.22,33.1 46.22,32.87 v1(46.41,32.68)
PP1800_H1_PG: length 142.6
  TOP w0.089: v2(124.01,52.84) 123.72,52.84 123.58,52.98 123.58,53.81 123.73,53.95 R90628.2
  IN2 w0.058: v3(53.7,12.5) 53.91,12.5 54.18,12.23 56.33,12.23 56.91,12.81 57.59,12.81 v2(57.89,13.12) 57.89,13.82 58.63,14.56 60.08,14.56 60.31,14.79 63.25,14.79 63.56,15.09 67.19,15.09 68.33,13.96 68.33,13.41 68.55,13.19 72.81,13.19 72.94,13.32 73.97,13.32 74.3,13.65 74.3,19.46 74.74,19.89 76.21,19.89 77.3,18.8 86.34,18.8 v3(86.47,18.68) ; v2(124.01,52.84) 124.04,52.86 127.67,52.86 127.92,52.61 127.92,51.9 128.76,51.06 128.76,49.28 129.78,48.27 129.78,47.65 130.97,46.46 130.97,45.5 130.79,45.32 128.66,45.32 127.91,44.58 125.57,44.58 125.06,45.09 122.92,45.09 122.72,44.9 121.01,44.9 120.05,45.85 118.19,45.85 117.99,45.65 117.99,45.29 119.79,43.49 119.79,36.18 120.56,35.41 120.56,34.01 119.93,33.38 119.93,32.57 119.59,32.24 119.26,32.24 119.03,32.47 118.85,32.47 118.52,32.14 118.52,31.76 117.32,30.55 117.32,30.45 116.65,29.77 116.29,29.77 v3(116.14,29.62)
  IN3 w0.102: v3(86.47,18.68) 87.08,18.68 88.16,19.76 91.52,19.76 92.68,20.93 98.31,20.93 100.6,23.22 101.95,23.22 102.38,23.65 102.38,24.43 101.91,24.9 101.91,25.76 102.91,26.75 104.1,26.75 104.45,27.11 106.1,27.11 106.97,27.97 109.15,27.97 109.49,28.31 115.1,28.31 116.14,29.34 v3(116.14,29.62)
  IN4 w0.058: v3(53.7,12.5) 53.27,12.07 51.16,12.07 50.53,11.44 49.64,11.44 49,12.07 47.99,12.07 47.61,12.45 47.61,14.84 46.34,16.11 v5(46.24,16.11)
  BOTTOM w0.089: v5(46.24,16.11) 42.83,16.11 42.47,16.47 Q802.3
PP1800_IT6505_A: length 34.4
  TOP w0.381: v2(35.14,28.12) v2(35.14,28.68) 35.14,29.65 34.68,30.11 R90354.2
  IN2 w0.381: v6(19.57,18.95) 21.9,18.95 22.17,18.69 22.73,18.69 22.89,18.52 23.35,18.52 23.68,18.85 23.68,19.08 24.01,19.41 24.01,25.61 24.54,26.14 33.16,26.14 v2(35.14,28.12) v2(35.14,28.68)
  BOTTOM w0.381: FB3.1 19.48,19.04 v6(19.57,18.95) FB4.1 20.29,18.81 20.73,18.37 20.73,15.86 21.58,15.01 FB2.1 FB5.1
PP1800_IT6505_D: length 17.7
  TOP w0.203: v2(26.65,15.83) 26.65,15.93 26.63,15.95 U1.51 ; v2(34.32,22.26) 34.26,22.32 U1.79 ; U1.63 31.43,15.93 31.35,15.86 v2(31.35,15.83) ; U1.55 28.23,15.78 v2(28.23,15.78) ; U1.20 v2(25.03,27.64) 25.23,27.64 25.43,27.44 U1.19 ; R90352.2 30.71,29.46 30.5,29.25 C24.1 30.5,27.99 30.63,27.85 U1.6 ; U1.85 v2(34.32,24.72)
  IN2 w0.203: v3(28.41,16.06) 28.23,15.89 v2(28.23,15.78) ; v2(26.65,15.83) 26.65,15.75 v3(26.91,15.5) ; v3(33.91,22.32) 33.98,22.26 v2(34.32,22.26) ; v3(25.03,27.24) v2(25.03,27.64) ; v2(31.35,15.83) 31.35,15.86 31.43,15.93 31.43,16.54 v3(31.38,16.59)
  IN2 w0.254: v3(33.91,22.32) 33.18,23.05 33.18,23.58 v2(34.32,24.72)
  IN4 w0.203: v5(31.28,16.95) 31.28,16.69 v3(31.38,16.59) ; v3(26.91,15.5) 27.42,15.5 v5(27.57,15.65) ; v3(33.91,22.32) v5(33.61,22.2) ; v5(28.41,16.39) v3(28.41,16.06)
  BOTTOM w0.203: C20.1 30.31,27.82 v6(30.39,27.9)
PP1800_IT6505_ENABLE: length 69.1
  IN2 w0.058: 82.23,36.85 80.93,36.85 80.61,37.17 80.35,37.17 78.6,38.92 77.63,38.92 77.06,39.49 77.06,40.79 74.98,42.87 74.98,46.55 74.71,46.81 74.71,47.93 73.44,49.2 69.09,49.2 68.26,48.37 67.71,48.37 66.77,47.43 65.07,47.43 63.96,46.31 60.61,46.31 59.75,45.45 56.84,45.45 55.68,44.28 46.41,44.28 45.59,43.46 42.29,43.46 41.86,43.89 39.42,43.89 38.84,43.31 37.9,43.31 36.37,41.79 35.21,41.79 33.43,40.01 33.43,35.49 33.61,35.32 33.61,34.1 v2(33.76,33.94)
  IN2 w0.06: v8(83.01,36.36) 82.83,36.53 82.83,36.85 82.71,36.97 82.46,36.97 82.33,36.85 82.23,36.85
PP1800_LDO:
  vias: v5(73.85,51.03) v5(73.85,50.7) v5(73.85,50.35) v5(73.87,50.04) v6(53.73,23.09) v6(54.44,23.09) v6(66.38,7.42) v6(66.96,6.99) v6(119.9,55) v6(120.51,54.62)
PP1800_LPDDR: length 27.1
  TOP w0.2: v8(81.51,47.92) 81.53,47.92 81.95,47.5 UD1.F1
  IN2 w0.15: v3(81.68,50.38) 81.68,50.08 81.43,49.84 81.43,48.94 81.52,48.85 81.52,48.31 81.51,48.3 v8(81.51,47.92)
  IN2 w0.2: v3(82.21,53.91) 82.23,53.89 v8(82.61,53.89) ; v3(88,49.98) 88.09,49.89 v8(88.45,49.89) ; v8(83.83,41.56) 83.68,41.72 v3(83.52,41.72) ; v8(89.1,47.5) 89.1,47.23 v3(89.05,47.17) ; v8(82.61,49.89) 82.79,50.08 v3(82.94,50.08)
  IN2 w0.203: v8(88.45,53.89) 88.06,53.89 v3(88.06,53.9) ; v8(89.1,56.3) 89.1,56.32 v3(88.84,56.58) ; v3(81.7,56.61) 81.7,56.55 v2(81.95,56.3)
  IN3 w0.25: v3(82.94,50.08) 82.6,50.42 81.87,50.42 81.68,50.41 v3(81.68,50.38) 81.59,50.47 81.59,53.28 v3(82.21,53.91) 82.33,54.02 82.33,55.27 81.82,55.78 81.82,56.49 v3(81.7,56.61)
  IN3 w0.3: 88.65,49.77 88.91,49.77 89.73,50.59 89.73,53.03 88.87,53.9 v3(88.06,53.9) 88.37,54.2 88.37,55.39 88.84,55.87 v3(88.84,56.58) ; 88.65,49.77 88.55,49.77 88.34,49.98 v3(88,49.98) ; 88.65,49.77 88.83,49.59 88.83,47.39 v3(89.05,47.17)
  vias: v1(75.93,44.1) v1(76.06,44.33) v1(76.18,44.1) v1(76.31,44.33) v1(76.44,44.1) v1(76.59,44.3) v1(85.3,57.62) v1(85.3,57.37) v1(85.3,57.11) v1(85.55,57.62) v1(85.55,57.37) v1(85.55,57.11) v1(85.8,57.62) v1(85.8,57.37) v1(85.8,57.11) v2(75.93,44.1) v2(76.06,44.33) v2(76.18,44.1) v2(76.31,44.33) v2(76.44,44.1) v2(76.59,44.3) v2(85.3,57.62) v2(85.3,57.37) v2(85.3,57.11) v2(85.55,57.62) v2(85.55,57.37) v2(85.55,57.11) v2(85.8,57.62) v2(85.8,57.37) v2(85.8,57.11) v3(76.08,44.96) v3(76.39,44.66) v3(83.09,41.59) v4(83.27,41.95) v4(83.32,41.25) v5(83.27,41.95) v5(83.32,41.25)
PP1800_MIPIBRDG_A: length 12.6
  TOP w0.508: R91234.1 71.01,48.66 v6(71.43,48.24)
  BOTTOM w0.508: v6(71.43,48.24) 71.43,48.11 69.58,46.26 69.58,44.43 68.84,43.69 68.84,40.72 68.05,39.93 66.45,39.93 66.26,40.13 C10679.1
  vias: v1(65.26,41.82) v1(65.66,41.82) v2(65.26,41.82) v2(65.66,41.82) v3(66,41.81) v3(66.02,41.18) v4(65.46,41.56) v4(66.13,41.51) v5(65.46,41.56) v5(66.13,41.51)
PP1800_MIPIBRDG_D: length 53.4
  TOP w0.203: R91253.1 60.59,44.64 60.74,44.79 61.4,44.79 v1(62.59,45.98)
  TOP w0.254: v1(57.13,39.63) 56.4,40.36 R91233.2 55.99,40.6 57.49,42.09 v6(57.49,42.6)
  TOP w0.508: v6(70.29,48.21) 70.23,48.21 70.21,48.24 70.13,48.24 R91235.1
  IN1 w0.254: v1(57.13,39.63) 57.51,39.63 58.91,38.23 v1(60.46,38.23) ; v6(70.29,48.21) 69.67,48.82 66.96,48.82 66.53,48.39 65.45,48.39 63.03,45.98 v1(62.59,45.98)
  IN2 w0.254: v3(66.14,42.5) 66.06,42.42 66.02,42.42 65.82,42.22 v2(65.66,42.22)
  IN4 w0.203: v5(67.01,45.07) 66.86,44.91 v5(65.74,44.91)
  IN4 w0.254: v3(66.14,42.5) 66.3,42.34 v5(66.3,42.2)
  BOTTOM w0.152: Q799.5 63.79,45.07 ; v5(67.01,45.07) Q800.5
  BOTTOM w0.203: v5(65.74,44.91) 65.77,44.94 R91241.1 65.44,45.32 65.42,45.3 R91240.1 64.76,45.3 64.47,45.01 63.84,45.01 63.79,45.07 63.74,45.01 63.25,45.01 62.57,45.7 62.44,45.7
  BOTTOM w0.508: v6(57.49,42.6) 58.91,44.02 60.77,44.02 62.44,45.7 62.44,47.45 62.73,47.75 66.31,47.75 67.41,48.85 69.65,48.85 v6(70.29,48.21) 70.29,47.96 68.82,46.49 68.82,44.61 68.18,43.97 68.18,41.65 67.93,41.39 C10676.1
PP1800_S3: length 112.2
  TOP w0.254: 50.96,6.62 50.5,7.08 50.5,7.52 50.7,7.72 Q768.1 ; v1(139.86,28.45) 139.86,26.42 139.68,26.24 139.68,24.69 138.11,23.12 130.54,23.12 129.93,22.51 v6(129.85,22.51) ; R90535.1 141.24,30.23 140.98,30.49 v1(140.09,30.49)
  TOP w0.381: v6(63.37,4.2) 63.37,5.14 63.6,5.36 63.6,12.09 63.36,12.33 63.36,19.71 62.81,20.26 R90629.2 62.64,21.77 60.46,23.96 60.46,32.14 60.18,32.42 60.18,33.56 61.17,34.55 61.17,36.53 v6(60.84,36.86)
  IN1 w0.254: v1(140.09,30.49) 139.86,30.26 v1(139.86,28.45)
  IN1 w0.381: v6(60.84,36.86) 58.66,36.86 56.27,39.25 55.99,39.25 55.48,39.76 55.48,40.09 56.02,40.62 56.02,42.07 57.16,43.21 58.28,43.21 60.33,45.27 61.53,45.27 62.09,44.72 v6(62.09,44.41)
  IN2 w0.381: v6(53.98,6.74) 53.98,6.08 54.42,5.64 56.14,5.64 56.88,4.91 57.67,4.91 58.56,5.8 59.29,5.8 60.82,4.27 61.98,4.27 62.41,4.7 62.87,4.7 v6(63.37,4.2)
  IN4 w0.381: v6(62.09,44.41) 62.09,45.17 v5(63.86,46.95) 64.17,46.95 64.5,47.28 66.68,47.28 v5(67.01,46.95) 67.04,46.95 68.99,48.9 69.76,48.9 70.44,49.59 v5(71.36,49.59) 71.36,49.62 v5(71.87,50.14)
  BOTTOM w0.381: v6(77.78,62.64) 75.85,60.71 75.85,58.17 73.13,55.45 73.13,51.4 v5(71.87,50.14) 71.87,50.1 v5(71.36,49.59)
  vias: v3(102.37,25.56) v3(102.37,25.15) v3(102.78,25.56) v3(102.78,25.15) v3(103.18,25.56) v3(103.18,25.15) v3(113.36,26.48) v3(113.55,25.96) v3(113.86,26.48) v3(114.05,25.96) v3(114.37,26.48) v3(114.56,25.96) v3(114.88,26.48) v3(115.07,25.96) v4(101.55,26.71) v4(101.55,26.41) v4(101.55,26.1) v4(101.81,26.71) v4(101.81,26.41) v4(101.81,26.1) v4(102.06,26.71) v4(102.06,26.41) v4(102.06,26.1) v4(102.31,26.71) v4(102.31,26.41) v5(101.55,26.71) v5(101.55,26.41) v5(101.55,26.1) v5(101.81,26.71) v5(101.81,26.41) v5(101.81,26.1) v5(102.06,26.71) v5(102.06,26.41) v5(102.06,26.1) v5(102.31,26.71) v5(102.31,26.41) v6(115.02,59.82) v6(115.35,60.46) v6(115.73,59.82) v6(116.06,60.46) v6(116.44,59.82) v6(128.76,21.88) v6(129.09,22.51) v6(129.47,21.88) v6(130.18,21.88)
PP1800_SENSOR: length 94.3
  TOP w0.152: v1(145.75,47.05) 144.18,47.05 143.92,46.79 143.92,39.88 144.66,39.15 R90871.2 R90872.2 149.24,39.15 v6(149.64,39.55) C10460.1 ; U6575.E5 146.79,45.3 v1(146.79,47.4) ; R90860.2 C10460.1 ; C10460.1 149.64,41.86 148.51,42.98 U6575.B2
  TOP w0.203: v1(146.79,31.4) 146.79,31.15 145.12,29.47 142.98,29.47 142.45,30.01 R7701.2 141.94,30.01 141.84,30.11 R90535.2 141.69,31.09 142,31.4 R90264.2 ; v1(148.32,33) 148.5,33 148.61,32.89 Q726.2 ; v2(146.29,37.63) 145.93,37.63 145.66,37.35 Q786.2 ; v1(148.32,34.65) 148.32,34.93 148.57,35.18 Q725.2 ; v1(146.29,36.33) R90995.2 145.24,36.05 145.14,35.95 R90417.1
  IN1 w0.152: v1(146.79,47.4) 146.79,47.32 146.52,47.05 v1(145.75,47.05)
  IN1 w0.203: v1(146.79,31.4) 148.32,32.93 v1(148.32,33) v1(148.32,34.65) 147.73,35.24 147.38,35.24 v1(146.29,36.33) v2(146.29,37.63)
  IN2 w0.203: v3(145.45,39.58) 145.65,39.38 145.65,38.11 146.13,37.63 v2(146.29,37.63)
  IN3 w0.203: v3(128.71,58.71) 128.71,58.55 129.47,57.79 131.71,57.79 132.85,56.65 132.85,56.42 133.18,56.09 133.82,56.09 134.22,55.68 134.22,54.06 135.1,53.19 135.1,47.69 135.19,47.6 135.19,44.86 136.2,43.85 138.24,43.85 140.96,41.13 142.14,41.13 143.77,39.5 145.37,39.5 v3(145.45,39.58) 145.66,39.38 146.44,39.38 146.57,39.5 147.18,39.5 148.58,38.11 150.15,38.11 150.35,38.31 150.35,39.12 149.92,39.55 v6(149.64,39.55)
  IN4 w0.203: v3(128.71,58.71) 128.35,58.35 127.54,58.35 125.87,60.03 125.87,62.87 v5(126.3,63.3)
PP1800_SPI_FLASH: length 32.7
  TOP w0.203: C434.2 48.4,14.71 48.37,14.74 U49.8
  TOP w0.381: 46.06,23.7 46.22,23.87 R90640.2 50.01,23.87 50.38,23.5 50.38,22.79 50.09,22.5 49.37,22.5 49.05,22.18 49.05,16.49
  IN2 w0.203: v3(59.39,12.07) 59.75,12.43 v2(59.75,12.65)
  IN3 w0.203: v3(59.39,12.07) 58.02,10.7 52.68,10.7 52.38,10.39 49.26,10.39 v3(48.85,10.8)
  IN4 w0.203: v3(48.85,10.8) v5(48.61,11.04)
  BOTTOM w0.203: CON16.6 46.9,9.33 v5(48.61,11.04) 48.8,11.23 48.8,13.37 v6(48.57,13.6)
PP1800_WLAN: length 17.3
  TOP w0.203: C10482.1 133.58,58.34 133.46,58.22 133.46,56.67 v6(133.43,56.65) ; C10482.1 R91066.2 ; C10482.1 133.58,59.06 133.94,59.42 133.94,59.77 135.8,61.63 137.32,61.63 138.18,60.76 R91137.2
  BOTTOM w0.203: 132.47,54.36 132.47,49.59 132.72,49.33 R91134.2
PP1800_WLAN_N: length 6.8
  IN4 w0.076: v5(119.77,62.62) 119.64,62.49 119.64,62.35 119.76,62.24 120.26,62.24 120.51,61.99 120.51,61.78 v5(120.76,61.52)
  BOTTOM w0.076: v5(119.77,62.62) 119.63,62.48 119.63,62.24 119.32,61.93 119.03,61.93 118.75,61.65 118.75,61.4 118.88,61.27 NC275.2 ; v5(120.76,61.52) 120.52,61.28 120.52,60.16 120.77,59.9 121.06,59.9 121.14,59.98 R90718.2
PP1800_WLAN_P: length 7
  IN4 w0.076: v5(119.34,62.62) 119.49,62.46 119.49,62.29 119.69,62.08 120.2,62.08 120.35,61.93 120.35,61.73 v5(120.15,61.52)
  BOTTOM w0.076: v5(119.34,62.62) 119.48,62.48 119.48,62.3 119.26,62.08 118.97,62.08 118.6,61.72 118.6,61.4 118.47,61.27 NC274.2 ; R90717.2 121.14,59.64 121.04,59.75 120.71,59.75 120.36,60.09 120.36,61.31 v5(120.15,61.52)
PP3000_EMMC: length 9.2
  IN1 w0.508: 111.41,41.39 112.02,42 112.3,42 112.91,42.61 112.91,44.32 113.29,44.7 113.29,46.28 113.77,46.76 113.77,48.48 114.43,49.14 114.35,49.14
  vias: v1(111.14,40.13) v1(111.39,40.13) v1(114.33,49.37) v1(114.58,49.37)
PP3000_EMMC_R: length 2.3
  TOP w0.203: U18.E6 v2(103.42,58.86) 103.45,58.86 103.89,58.41 U18.F5
  IN2 w0.254: v2(103.42,58.86) 103.58,58.86 103.84,59.11 v3(103.84,59.14)
  IN4 w0.203: v3(105.49,60.01) 105.58,60.01 105.72,60.15 v5(105.86,60.15) ; v5(103.86,58.53) 103.84,58.56 v3(103.84,59.14)
  vias: v1(105.39,60.85) v1(105.89,60.36) v2(105.39,60.85) v2(105.89,60.36) v3(105.39,60.48) v6(108.69,60.31)
PP3300_ALW: length 181.8
  TOP w0.178: R90861.1 v6(6.23,24.14) ; v6(8.01,34.6) 8.31,34.3 R90529.1 ; U6533.A3 25.14,43.93 24.98,43.77 24.98,43.34 25.28,43.03 C10412.2 25.83,42.79 25.94,42.68 25.94,41.66 25.13,40.85 25.13,39.38 26.51,38 v2(26.58,38) ; R91052.1 v2(140.54,25.79) ; v1(116.31,57.66) 115.79,57.14 R90465.1 ; U6555.12 19.32,42.84 18.78,42.3 C10604.1 18.37,42.61 18.22,42.75 17.51,42.75 v6(17.43,42.83) ; R91210.1 141.84,22.26 142.12,22.54 R91051.1 142.38,22.23 142.5,22.1 143.01,22.1 143.21,21.9 143.21,21.72 143.54,21.39 143.76,21.39 R90855.2 ; v1(123.22,67.09) 123.45,67.09 123.53,67.16 C10688.1 126.47,67.82 127.1,68.45 U6580.3 ; C175.1 24.37,31.07 23.89,30.59 C748.1 23.89,30.26 23.58,29.95 23.25,29.95 23.01,30.2 U93.30
  TOP w0.508: R218.2 71.79,41.87 71.79,45.75 v6(70.9,46.64)
  IN1 w0.178: v1(123.22,67.09) 123.8,67.09 125.2,65.69 125.2,60.53 123.05,58.38 122.36,58.38 121.17,57.18 121.17,55.84 121.27,55.73
  IN1 w0.381: 131.94,52.33 132.62,51.64 132.62,50.3 132.95,49.97 132.95,40.52 135.64,37.83 139.33,37.83 141.36,35.79 141.36,27.57 140.7,26.91 v2(140.7,26.72) 140.7,25.95 v2(140.54,25.79) ; v1(116.31,57.66) 116.59,57.38 118.73,57.38 120.38,55.73 v1(121.89,55.73) 122.1,55.53 124.27,55.53 124.54,55.25 126.6,55.25 127.97,56.62 v1(128.13,56.62) 129.22,56.62 129.84,56 131.41,56 v1(131.43,56.01) 131.43,55.66 131.05,55.28 130.41,55.28 130.03,54.9 130.03,53.44 130.94,52.53 131.17,52.53 ; v6(133.33,13.98) 133.43,13.98 134.6,15.14 136.81,15.14 138.24,16.57 142.86,16.57 143.92,17.63 143.92,19.87 v6(144.97,20.91)
  IN1 w0.508: v6(70.9,46.64) 69.68,47.86 65.67,47.86 63.25,45.45 62.2,45.45 61.78,45.87 59.79,45.87 58.85,44.93 48.8,44.93 48.69,44.81 46.06,44.81 43.8,42.55 42.35,42.55 v6(40.95,41.15)
  IN2 w0.178: v2(140.7,26.72) 140.52,26.9 v3(140.52,27.18) ; v3(26.14,38) v2(26.58,38) ; v2(24.37,31.44) 24.37,31.5 23.88,31.98 v3(23.88,32.11)
  IN2 w0.203: v2(52.48,31.74) 52.48,31.96 v3(53.17,32.64)
  IN2 w0.381: v3(140.67,25.41) 140.67,25.66 v2(140.54,25.79)
  IN3 w0.381: v3(23.88,32.11) 23.63,32.37 19.34,32.37 17.94,33.76 v6(17.94,34.52)
  IN4 w0.178: v4(53.4,32.87) v3(53.17,32.64) ; v3(26.14,38) v5(26.53,38) ; v5(141.28,27.49) 140.88,27.49 140.57,27.18 v3(140.52,27.18)
  IN4 w0.381: v3(140.67,25.41) 140.67,25.05 v5(140.7,25.03)
  IN5 w0.178: v4(53.4,32.87) 53.68,33.15 55.69,33.15 56.62,34.09 56.62,35.49 v5(56.96,35.82)
  BOTTOM w0.178: R91317.1 71.1,46.84 v6(70.9,46.64)
  BOTTOM w0.254: v6(144.97,20.91) 144.08,21.8 140.5,21.8 140.19,22.1 140.19,23.79 140.7,24.3 v5(140.7,25.03)
  vias: v1(48.6,7.88) v1(48.6,7.58) v1(48.9,7.88) v1(131.3,52.46) v1(131.76,52.46) v2(48.6,7.88) v2(48.6,7.58) v2(48.9,7.88) v6(15.83,23.68) v6(15.83,22.92) v6(16.42,13.09) v6(16.92,12.58) v6(34.37,38.79) v6(34.37,38.03) v6(34.86,39.33) v6(40.19,41.15) v6(40.57,40.54) v6(49.77,12.5) v6(50.25,11.97) v6(50.76,12.5) v6(70.7,4.12) v6(71.41,4.12) v6(72.12,4.12)
PP3300_ALW_N: length 22.9
  TOP w0.076: R90488.1 43.95,25.33 44.13,25.33 44.45,25.66 44.45,26.11 44.14,26.43 44.14,28.32 44.61,28.79 44.61,33.01 44.83,33.23 45.51,33.23 46.3,34.03 51.06,34.03 52.01,34.98 54.27,34.98 54.44,34.81 54.44,34.65 54.31,34.52 v6(54.16,34.52)
  BOTTOM w0.076: NC293.2 55.89,34.58 55.71,34.58 55.1,35.19 54.66,35.19 54.47,34.99 54.47,34.83 v6(54.16,34.52)
PP3300_ALW_P: length 22.9
  TOP w0.076: R90489.1 43.95,25.48 44.07,25.48 44.3,25.72 44.3,26.05 43.98,26.37 43.98,28.38 44.46,28.86 44.46,33.08 44.77,33.39 45.44,33.39 46.24,34.18 51,34.18 51.95,35.13 54.33,35.13 54.59,34.87 54.59,34.68 54.75,34.52 v6(54.87,34.52)
  BOTTOM w0.076: NC294.2 55.89,34.42 55.65,34.42 55.04,35.03 54.72,35.03 54.62,34.93 54.62,34.78 v6(54.87,34.52)
PP3300_ALW_PG: length 9.9
  TOP w0.254: Q806.1 49.01,27.41 47.88,28.54 Q804.2 47.88,29.79 48.32,30.23 48.95,30.23 v6(49.26,30.54) 48.95,30.84 48.12,30.84 47.71,31.25 R91305.1
  BOTTOM w0.203: U6571.7 49.79,30.97 49.63,31.12 PP3300_ALW_PG.1 48.83,30.97 v6(49.26,30.54)
PP3300_CTP: length 20.1
  TOP w0.152: Q779.2 54.97,47.63 55.18,47.83 ; v1(44.66,46.51) 45.29,46.51 45.34,46.47 45.8,46.47 45.98,46.65 Q777.2 ; Q776.2 42.4,47.55 42.55,47.4 43.04,47.4 43.21,47.22 43.21,46.81 43.51,46.52 R91126.1 ; R91132.1 55.71,47.3 55.18,47.83 ; 55.18,47.83 55.18,48.22 55.08,48.32 52.48,48.32 52.23,48.06 52.23,47.75 52.08,47.6 R91129.1 51.29,47.6 v1(51.27,47.63) Q778.2
  IN2 w0.381: v2(53.7,46.87) v3(53.7,46.36)
  IN4 w0.381: v5(53.32,38.08) 53.5,38.26 53.5,39.81 54.21,40.52 54.21,45.42 53.7,45.93 v3(53.7,46.36)
  vias: v1(43.87,46.54) v1(55.74,47.22)
PP3300_CTP_N: length 7.8
  TOP w0.076: R90490.1 43.9,30.13 43.65,30.38 43.65,30.65 43.02,31.27 42.32,31.27 42.02,31.58 42.02,31.76 v6(42.31,32.05)
  BOTTOM w0.076: v6(42.31,32.05) 42.1,32.26 42.1,32.38 42.21,32.49 42.58,32.49 42.88,32.19 44.99,32.19 45.14,32.34 45.14,32.62 45.22,32.7 NC267.1
PP3300_CTP_P: length 7.8
  TOP w0.076: R90491.1 43.29,30.13 43.49,30.33 43.49,30.59 42.96,31.12 42.26,31.12 41.87,31.52 41.87,31.81 v6(41.59,32.09)
  BOTTOM w0.076: NC266.1 44.92,32.7 44.99,32.62 44.99,32.4 44.93,32.34 42.95,32.34 42.64,32.65 42.15,32.65 v6(41.59,32.09)
PP3300_EC: length 27.8
  TOP w0.381: R90367.2 132.32,52.96 132.32,51.19 132.16,51.03 132.16,50.02 133.25,48.94 R91304.2 134.32,46.83 134.32,43.87 133.79,43.34 132.7,43.34 132.34,43.69 126.7,43.69 125.05,42.04 123.74,42.04 122.59,40.89 122.59,37.58 R521.2
PP3300_EDP_DX:
  vias: v6(46.49,37.98) v6(47.2,37.95)
PP3300_EDP_DX_N: length 8.9
  TOP w0.076: R90540.1 49.41,39 49.54,38.87 49.54,38.7 49.42,38.59 48.21,38.59 47.91,38.3 47.91,37.71 47.57,37.37 46.03,37.37 45.88,37.52 45.88,38.08 44.64,39.33 44.64,40.01 44.79,40.16 44.92,40.16 44.97,40.11 NC268.1
PP3300_EDP_DX_P: length 9.7
  TOP w0.076: R90539.1 49.8,39 49.69,38.89 49.69,38.64 49.49,38.44 48.27,38.44 48.07,38.23 48.07,37.65 47.63,37.22 45.97,37.22 45.73,37.46 45.73,38.02 44.48,39.26 44.48,40.07 44.73,40.32 44.92,40.32 44.97,40.37 NC269.1
PP3300_H1: length 257
  TOP w0.152: Q739.2 v1(123.3,44.46) R90376.2 ; R90374.1 58.78,13.67 57.46,14.99 57.26,14.99 56.98,15.27 v2(56.98,15.41)
  TOP w0.381: R91182.1 119.36,39.88 v1(120.63,41.15) v1(121.27,41.15)
  IN1 w0.152: v2(53.98,15.9) 53.48,16.4 v2(53.48,18.41)
  IN1 w0.381: v1(120.63,41.15) v1(121.27,41.15) 123.17,43.06 123.17,44.33 v1(123.3,44.46) 129.01,44.46 v2(129.14,44.58) v2(129.65,44.58)
  IN2 w0.152: v3(50.05,19.01) v2(50.05,19.34) ; v3(53.17,18.29) 53.37,18.29 v2(53.48,18.41)
  IN2 w0.254: v3(12.89,34.35) 12.56,34.68 v6(12.56,37.26)
  IN3 w0.254: v3(130.28,44.58) 130.28,44.96 129.78,45.47 129.78,46.56 129.01,47.33 129.01,53.98 128.15,54.84 127.39,54.84 121.88,60.36 121.88,61.12 121.46,61.54 120.71,61.54 116.48,65.77 76.56,65.77 72.04,61.25 71.01,61.25 68.63,58.87 68.63,54.42 67.37,53.17 v3(67.37,51.9) ; v3(12.89,34.35) 12.99,34.25 12.99,27.51 13.24,27.26 v3(13.55,27.26) 14.11,26.7 14.11,22.74 13.8,22.43 13.8,21.55 15.17,20.17 15.38,20.17 17.18,18.37 20.25,18.37 20.56,18.07 20.56,16.64 21.6,15.6 23.88,15.6 25.99,13.49 28.89,13.49 29.02,13.37 35.11,13.37 36.03,14.28 42.12,14.28 42.65,14.81 50.63,14.81 51.19,14.26 52.84,14.26 v3(53.02,14.43)
  IN4 w0.152: v5(53.7,18.42) 53.3,18.42 v3(53.17,18.29) ; v5(46.73,19.03) 50.02,19.03 v3(50.05,19.01) ; v3(57.34,14.92) 57.23,14.92 57.18,14.87 v4(57.01,14.87)
  IN4 w0.254: v3(13.55,27.26) 14.21,27.26 v5(15.38,28.43) ; v5(40.8,46.92) 41.11,46.92 42.85,48.65 56.04,48.65 57.26,47.43 57.87,47.43 59.09,48.65 60.82,48.65 63,50.83 63.76,50.83 64.83,51.9 v3(67.37,51.9) ; v5(54.21,16.26) 53.98,16.03 52.71,16.03 52.56,15.88 52.56,15.32 v5(52.97,14.92) 52.97,14.48 v3(53.02,14.43)
  IN5 w0.152: v5(56.35,14.87) v4(57.01,14.87)
  BOTTOM w0.152: v5(15.38,28.43) 15.49,28.55 Q780.2 ; v5(56.35,14.87) C10368.1 ; R91278.2 v5(46.73,19.03)
  BOTTOM w0.203: R91312.2 53.2,13.44 53.2,14.69 v5(52.97,14.92)
  BOTTOM w0.254: v5(40.8,46.92) 35.84,46.92 35.39,47.37 32.64,47.37 31.29,48.72 23.05,48.72 22.74,48.42 22.74,45.93 24.79,43.88 24.79,43.1 24.32,42.63 23.14,42.63 22.68,43.09 20.32,43.09 19.79,43.62 16.45,43.62 16.23,43.39 16.23,42.44 16.56,42.11 16.56,39.33 14.57,37.34 12.64,37.34 v6(12.56,37.26)
  vias: v1(50.65,15.5) v1(50.66,16.54) v1(50.66,16.29) v1(50.66,16.03)
PP3300_H1_EC: length 152.5
  TOP w0.254: v1(125.7,43.38) 126.5,44.18 132.62,44.18 132.95,43.85 133.61,43.85 133.84,44.08 133.84,45.29 132.05,47.09 R91304.1 ; PC140.1 51.69,31.03 51.88,30.84 51.88,28.81 52.28,28.4 52.99,28.4 53.43,27.96 Q805.1 53.43,26.31 53.09,25.96 R91309.2 ; PC140.1 50.74,31.03 49.78,30.06 Q804.1 ; PC140.1 R91307.1 51.89,32.18 52.89,33.18 55.33,33.18 55.84,32.67 v1(57.67,32.67) ; v2(104.87,13.53) 106.1,12.3 113.44,12.3 114.49,13.34 114.49,15.15 115.53,16.19 116.3,16.19 116.44,16.34 117.53,16.34 v1(118.12,16.92) ; v2(94.45,14.38) 93.63,14.38 91.8,12.55 78.4,12.55 74.95,9.1 73.72,9.1 ; 71.69,12.05 69.1,12.05 68.18,12.96 68.18,14.94 67.29,15.83 67.29,18.42 67.12,18.6 65.82,18.6 65.77,18.55 64.75,18.55 63.86,19.44 63.86,19.89 63.43,20.33 63.43,21.72 60.94,24.21 60.94,32.87 60.71,33.1 v1(60.69,33.1)
  IN1 w0.254: v1(118.12,16.92) 118.3,16.92 120.56,19.18 120.56,25.36 120.96,25.76 120.96,27.39 120.66,27.69 120.66,35.24 119.82,36.08 119.82,38.94 124.25,43.38 v1(125.7,43.38) ; v1(60.69,33.1) 60.36,33.1 60.16,33.31 59.39,33.31 59.29,33.41 58.4,33.41 v1(57.67,32.67)
  IN2 w0.254: v2(104.87,13.53) 104.69,13.71 102.48,13.71 102.38,13.61 100.02,13.61 99.45,14.18 94.65,14.18 v2(94.45,14.38)
  IN2 w0.508: 71.51,11.74 65.85,11.74 65.42,12.17 64.55,12.17
  vias: v1(61.12,11.97) v1(61.43,11.97) v1(61.73,11.97) v1(72.04,11.84) v1(72.35,11.84) v1(72.65,11.84) v2(61.12,11.97) v2(61.43,11.97) v2(61.73,11.97) v2(72.04,11.84) v2(72.35,11.84) v2(72.65,11.84)
PP3300_H1_N: length 71.3
  TOP w0.076: R90498.1 118.01,12.74 118.09,12.66 118.09,12.11 116.8,10.81 116.55,10.81 v2(116.49,10.75) ; v2(54.62,9.53) 54.62,9.61 54.49,9.74 54.49,10.27 54.24,10.52 54.24,10.83 54.37,10.96 NC250.2
  IN2 w0.076: v2(54.62,9.53) 54.62,9.51 54.67,9.45 54.78,9.45 55.07,9.74 58.11,9.74 58.57,10.2 60.82,10.2 61,10.01 67.04,10.01 67.25,9.8 67.5,9.8 67.71,10.01 73.09,10.01 73.95,10.87 75.3,10.87 78.1,13.67 79.32,13.67 79.81,14.15 86.22,14.15 87.21,13.16 90.38,13.16 92.26,11.28 98.09,11.28 98.62,11.82 101.61,11.82 101.92,11.51 113.03,11.51 113.44,11.09 114.76,11.09 115.28,10.57 116.45,10.57 116.49,10.61 v2(116.49,10.75)
PP3300_H1_P: length 71.9
  TOP w0.076: R90499.1 118.25,12.51 118.25,12.05 116.9,10.7 116.9,10.7 116.8,10.6 v2(116.8,10.49) ; v2(54.21,9.53) 54.21,9.61 54.33,9.73 54.33,10.21 54.09,10.46 54.09,10.75 53.88,10.96 NC249.2
  IN2 w0.076: v2(116.8,10.49) 116.73,10.42 115.22,10.42 114.7,10.94 113.38,10.94 112.96,11.36 101.85,11.36 101.54,11.67 98.69,11.67 98.15,11.13 92.2,11.13 90.32,13.01 87.15,13.01 86.16,14 79.87,14 79.39,13.52 78.16,13.52 75.37,10.72 74.02,10.72 73.15,9.86 67.77,9.86 67.56,9.65 67.19,9.65 66.98,9.86 60.94,9.86 60.75,10.04 58.63,10.04 58.17,9.58 55.13,9.58 54.74,9.2 54.5,9.2 54.21,9.48 v2(54.21,9.53)
PP3300_HUB: length 147.4
  TOP w0.254: R91100.2 63.16,32.28 62.96,32.48 62.58,32.48 61.96,33.1 ; U6546.9 67.44,24.81 67.31,24.69 65.99,24.69 65.72,24.42 v1(65.72,24.16) ; 61.96,33.1 61.96,34.17 61.64,34.49 61.64,37.81 v1(61.35,38.11) ; 61.96,33.1 61.35,32.49 61.35,28.17 v2(62.04,27.49) ; v2(72.47,62.34) 73.74,61.07 v1(73.74,42.37)
  IN1 w0.254: v1(65.72,24.16) 67.95,24.16 68.77,23.35 v1(70.62,23.35) ; v1(73.74,42.37) 73.34,41.97 73.34,39 73.14,38.8 71.78,38.8 71.33,38.35 67.95,38.35 66.68,39.62 64.56,39.62 63.72,38.77 61.63,38.77 61.35,38.49 v1(61.35,38.11)
  IN2 w0.254: v2(72.47,62.34) 71.97,61.83 v3(71.76,61.83) ; v2(64.4,27.62) 63.53,27.62 63.41,27.49 v2(62.04,27.49)
  IN3 w0.203: v3(71.76,61.83) 71.92,61.83 76.37,66.27 116.68,66.27 120.92,62.03 121.67,62.03 122.39,61.32 122.39,60.55 126.44,56.5 127.36,56.5 128.18,55.68 128.18,55.43 129.51,54.1 129.51,47.53 130.55,46.49 130.92,46.49 131.3,46.11 131.3,44.2 134.83,40.67 137.24,40.67 v3(137.27,40.64)
  IN4 w0.203: v3(137.27,40.64) v5(137.27,40.04)
  BOTTOM w0.203: v5(137.27,40.04) 137.63,40.04 137.72,39.94 R91225.1
PP3300_INA: length 48.2
  TOP w0.152: Q81.5 40.72,5.34 40.77,5.38 40.77,5.4 40.93,5.57 40.95,5.57 40.95,5.57 41.64,5.57 42.17,5.04 42.17,4.47 R90484.1 40.62,2.91 36.46,2.91 35.9,3.48 35.9,6.38 36.18,6.66 36.18,11.92
  IN2 w0.152: v2(38.16,13.44) 38.44,13.44 v3(38.54,13.54) ; v2(121.98,31.62) v3(121.98,31.28)
  IN2 w0.381: v2(122.03,24.67) 124.67,24.67 125.59,23.76 v3(125.59,23.58)
  IN3 w0.381: v3(125.59,23.58) 125.59,22.87 127.4,21.05 127.4,17.41 127.67,17.14 127.67,15.55 126.98,14.87 v3(126.98,13.72)
  IN4 w0.152: v5(38.49,13.09) 38.49,13.42 38.54,13.47 v3(38.54,13.54) ; v5(123,31.28) v3(121.98,31.28)
  BOTTOM w0.152: 39.45,11.45 39.45,11.89 39.18,12.16 39.18,12.55 38.64,13.09 v5(38.49,13.09) ; 39.45,11.45 R90483.1 ; 39.45,11.45 39.99,11.99 Q80.5 ; v5(123,31.28) 122.46,31.28 122.45,31.29 U6540.8 120.52,31.29 120.46,31.35 120.46,32.87 120.09,33.24 U6540.4
  BOTTOM w0.254: 128.89,59.59 130.31,59.59 130.98,60.26 U6538.8
  vias: v1(39.25,23.88) v1(39.35,23.65) v1(39.53,23.88) v1(40.83,26.6) v1(40.83,26.19) v1(41.44,29.17) v1(41.38,26.68) v1(41.89,29.18) v1(42.4,29.19) v1(54.59,40.49) v1(54.69,43.65) v1(54.84,40.5) v1(55.1,43.67) v1(56.36,33.11) v1(56.62,33.11) v1(56.87,33.11) v1(57.13,33.11) v1(58.28,44.3) v1(58.28,44.05) v1(61.68,47.66) v1(61.68,47.4) v1(61.96,47.66) v1(61.96,47.4) v1(121.73,24.67) v1(125.2,13.75) v1(125.43,13.85) v2(39.25,23.88) v2(39.35,23.65) v2(39.53,23.88) v2(40.83,26.6) v2(40.83,26.19) v2(41.44,29.17) v2(41.38,26.68) v2(41.89,29.18) v2(42.4,29.19) v2(43.9,30.88) v2(43.92,30.58) v2(44.16,30.88) v2(44.17,30.58) v2(125.2,13.75) v2(125.43,13.85) v2(129.17,43.77) v2(129.78,43.77) v6(72.98,67.16) v6(72.98,66.45) v6(127.34,60.08) v6(128.71,65.87) v6(129.42,65.87)
PP3300_KBC: length 18
  TOP w0.203: U6559.37 136.72,18.08 136.23,18.58 v2(135.75,18.58) ; v2(139.43,11.28) 139.43,11.56 139.7,11.83 U6559.4
  IN2 w0.203: v3(135.48,18.31) v2(135.75,18.58) ; v2(139.43,11.28) 139.65,11.28 v3(139.81,11.44)
  IN2 w0.254: v2(136.55,11.74) v3(136.88,11.74)
  IN5 w0.508: 139.28,10.55 143.24,10.55 147.38,14.69 147.38,17.28 146.92,17.74 v6(146.92,17.84)
  vias: v3(138.92,11.18) v9(138.92,10.72) v9(139.2,10.72)
PP3300_MIPIBRDG_DX: length 3.8
  IN2 w0.254: v2(64.46,42.22) 64.32,42.09 v3(64.32,41.92)
  BOTTOM w0.254: v5(63.99,42.06) 63.99,41.46 C10673.1 63.37,41.3 C10675.1 62.66,41.14 62.54,41.26 v6(62.54,42.17)
  vias: v1(39.48,37.75) v1(39.45,37.37) v1(39.96,37.75) v1(39.96,37.39) v1(47.23,42.78) v1(47.48,42.78) v1(47.73,42.78) v1(47.99,42.78) v1(52,38.82) v1(51.98,38.49) v2(39.48,37.75) v2(39.45,37.37) v2(39.96,37.75) v2(39.96,37.39) v2(47.23,42.78) v2(47.48,42.78) v2(47.73,42.78) v2(47.99,42.78) v2(52,38.82) v2(51.98,38.49)
PP3300_S3: length 42.9
  TOP w0.203: U6574.1 148.05,37.99 147.97,38.08 v2(147.38,38.08)
  IN2 w0.203: v3(147.62,38.32) v2(147.38,38.08)
  IN4 w0.254: v4(137.04,41.28) 138.92,41.28 140.04,40.16 143.47,40.16 143.95,40.65 146.41,40.65 147.62,39.44 v3(147.62,38.32)
  IN5 w0.508: 47.3,33.46 47.23,33.38 47.23,28.56 49.92,25.86 49.92,17.13 50.27,16.77 50.27,15.5 49.39,14.61 49.39,13.21 49,12.83 49,11.56 50.4,10.17 53.2,10.17
  vias: v1(61.76,32.07) v1(61.76,31.81) v1(61.76,31.56) v1(61.76,31.31) v2(61.76,32.07) v2(61.76,31.81) v2(61.76,31.56) v2(61.76,31.31) v3(42.48,43.87) v3(42.99,43.87) v3(43.43,33.03) v3(43.49,43.87) v3(43.89,33.03) v3(44,43.87) v3(44.51,43.87) v3(45.02,43.87) v3(51.47,28.71) v3(51.98,28.71) v4(42.35,43.57) v4(42.6,43.57) v4(42.86,43.57) v4(43.11,43.57) v4(43.37,43.57) v4(43.62,43.57) v4(43.67,34.27) v4(43.87,43.57) v4(43.95,34.25) v4(44.13,43.57) v4(44.23,34.25) v4(44.38,43.57) v4(44.48,34.25) v4(44.64,43.57) v4(44.89,43.57) v4(45.14,43.57) v5(42.35,43.57) v5(42.6,43.57) v5(42.86,43.57) v5(43.11,43.57) v5(43.37,43.57) v5(43.62,43.57) v5(43.7,34.78) v5(43.7,34.52) v5(43.67,34.27) v5(43.87,43.57) v5(43.95,34.78) v5(43.95,34.52) v5(43.95,34.25) v5(44.13,43.57) v5(44.2,34.78) v5(44.2,34.52) v5(44.23,34.25) v5(44.38,43.57) v5(44.46,34.78) v5(44.46,34.52) v5(44.48,34.25) v5(44.64,43.57) v5(44.89,43.57) v5(45.14,43.57) v5(53.17,10.02) v5(53.44,10.02) v6(60.26,50.81) v6(60.59,51.44) v6(60.97,50.76) v6(61.3,51.42) v6(61.68,50.73) v6(62.01,51.36) v6(67.85,61.55) v6(67.98,62.31) v6(68.46,62.97) v6(68.61,61.55) v6(68.79,62.26) v6(69.25,63) v6(121.17,63.24) v6(121.88,63.24) v6(131.48,22.51) v6(131.86,21.88) v6(132.19,22.51) v6(132.27,56.39) v6(132.27,55.68) v6(132.57,21.88) v6(132.9,22.51) v6(133.28,21.88) v6(133.89,22.26)
PP3300_SERVO_INA: length 18.5
  TOP w0.381: R90987.1 41.13,8.79 39.78,8.79 39.66,8.91 38.83,8.91 38.72,9.02 ; R90986.1 39.56,12.45 39.18,12.07 39.02,12.07 38.72,11.77 38.72,9.02 ; 38.72,9.02 38.45,9.02 37.96,8.54 36.85,8.54 36.61,8.3 36.61,6.43 36.33,6.15 36.33,3.64 36.64,3.33 39.27,3.33 R476.1
PP3300_THRM: length 1.5
  BOTTOM w0.254: R91317.2 R91318.2 R91320.1
PP3300_THRM_R: length 3.1
  BOTTOM w0.254: R91320.2 C10711.1 72.62,43.83 72.36,44.09 U6581.5
PP3300_TPAD: length 7.3
  TOP w0.203: Q732.1 54.09,3.49 54.21,3.61 54.21,4.22 53.6,4.83 R91113.1 53.29,5.23 53.55,5.49 Q731.1 53.99,5.75 54.11,5.88 R91112.1 54.77,5.88 55,6.11 v6(55,6.66) 55,6.89 54.61,7.27 R9499.1 Q730.1
PP3300_WLAN: length 42.3
  TOP w0.203: v6(147.26,60.59) 147.26,60.54 147.02,60.3 143.14,60.3 142.48,60.97 142.22,60.97 140.7,62.49 140.7,62.62 139.99,63.33 C10422.1 139.7,63.81 139.21,64.3 R90624.1 R90627.1 137.59,64.47 137.59,66.36 136.71,67.24 132.57,67.24 130.48,65.16 130.48,60.51 131.37,59.62 C10423.1 C10421.1 C10420.1 133.28,59.32 133.16,59.19 132.9,59.19 132.75,59.04 132.75,58.68 132.55,58.48 ; NC273.1 131.55,58.48 R91136.2 132.54,58.48 132.55,58.48 ; 132.55,58.48 132.93,58.1 132.93,56.42 133.42,55.92 133.42,51.73 135.08,50.07 R90843.2
  vias: v4(147.43,49.23) v4(147.43,48.95) v4(147.68,49.23) v4(147.68,48.95) v4(147.94,49.23) v4(147.94,48.95) v5(147.43,49.23) v5(147.43,48.95) v5(147.68,49.23) v5(147.68,48.95) v5(147.94,49.23) v5(147.94,48.95) v6(147.98,60.59)
PP3300_WLAN_N: length 3.3
  TOP w0.076: v2(130.21,57.56) 130.41,57.77 130.41,57.88 130.6,58.07 130.92,58.07 131.07,58.22 NC273.2
  IN2 w0.076: v3(130.33,57.23) v2(130.21,57.56)
  IN4 w0.076: v5(130.21,56.19) 130.42,56.19 130.56,56.34 130.56,57 v3(130.33,57.23)
PP3300_WLAN_P: length 3.2
  TOP w0.076: v2(130.72,57.56) 130.56,57.71 130.56,57.82 130.67,57.92 130.95,57.92 131.07,57.79 NC272.2
  IN2 w0.076: v2(130.72,57.56) v3(130.95,57.26)
  IN4 w0.076: v3(130.95,57.26) 130.72,57.03 130.72,56.34 130.87,56.19 v5(131.02,56.19)
PP5000_ALW: length 61.4
  IN2 w0.254: v2(130.54,15.02) v3(130.54,14.61)
  IN3 w0.254: v3(130.54,14.61) 130.64,14.71 130.64,16.03 135.03,20.43 138.41,20.43 141.23,23.25 141.23,34.65 138.54,37.34 135.49,37.34 134.98,37.85 133.26,37.85 130.89,40.21 130.67,40.21 129.75,41.13 v3(129.75,41.18)
  IN4 w0.254: v3(129.75,41.18) 129.75,42.25 v5(130.01,42.5)
  IN5 w0.203: v5(104.02,41.24) 104.07,41.29 104.07,42.49 105.34,43.75 105.34,49.39 104.48,50.25 101.51,50.25
  BOTTOM w0.102: SH2302.1 108.94,41.52
  BOTTOM w0.203: v5(104.02,41.24) R90876.2 104.41,40.88 104.55,40.73 107.32,40.73 108.11,41.52 108.94,41.52
  vias: v1(19.16,4.53) v1(19.16,4.2) v1(26.04,44.37) v1(26.4,44.3) v1(35.39,8.77) v1(35.39,8.46) v1(101.2,50.22) v1(101.2,49.97) v1(101.46,50.22) v1(101.46,49.97) v1(102.04,49.97) v1(102.12,50.25) v1(102.29,50.02) v1(102.46,50.24) v2(19.16,4.53) v2(19.16,4.2) v2(26.04,44.37) v2(26.4,44.3) v2(35.39,8.77) v2(35.39,8.46) v2(101.2,50.22) v2(101.2,49.97) v2(101.46,50.22) v2(101.46,49.97) v2(102.04,49.97) v2(102.12,50.25) v2(102.29,50.02) v2(102.46,50.24) v3(18.86,4.32) v3(26.2,44.66) v3(35.77,8.69) v3(101.53,50.55) v3(101.79,50.18) v3(101.94,50.58) v3(102.34,50.55) v4(18.83,4.65) v4(19.08,4.65) v4(26.53,45.35) v4(35.39,8.77) v4(35.39,8.46) v4(100.72,51.14) v4(100.95,50.51) v4(100.97,51.02) v4(100.97,50.25) v4(101.23,50.76) v4(101.2,50.51) v4(101.23,50.25) v5(15.78,26.5) v5(21.07,42.3) v5(26.53,45.35) v6(33.1,44.86) v6(33.1,44.15) v6(33.87,44.89) v6(33.87,44.15) v6(34.63,44.63) v6(34.55,43.92) v6(76.69,17.58) v6(76.74,16.36) v6(77.1,17) v6(77.81,16.82) v6(78.49,17.05) v6(115.65,43.52) v6(115.65,42.81) v6(116.37,43.49) v6(116.37,42.78)
PP5000_PMIC: length 10.7
  TOP w0.127: R90646.1 105.95,31.86 105,32.81 R2001.1
  TOP w0.381: R90646.1 106.36,31.65 107.09,30.91 107.09,29.42 107.78,28.73 108.67,28.73
  IN4 w0.127: v3(112.35,38.42) v4(112.35,38.75)
  IN5 w0.127: v4(112.35,38.75) 112.24,38.75 111.89,39.1 110.35,39.1 109.99,39.46 109.04,39.46 v5(108.86,39.64)
  vias: v1(97.29,41.66) v1(97.32,41.33) v1(97.31,41.06) v1(97.39,40.82) v1(97.54,41.66) v1(97.62,40.57) v1(97.85,40.42) v1(98.1,40.48) v1(98.08,40.22) v1(98.97,35.06) v1(98.99,34.79) v1(99.25,35.06) v1(102.19,48.7) v1(102.19,48.45) v1(102.45,48.7) v1(102.45,48.45) v1(102.83,48.7) v1(102.83,48.45) v1(103.21,48.7) v1(103.21,48.45) v1(103.44,49.21) v1(103.46,48.7) v1(103.46,48.45) v1(103.59,49.42) v1(103.69,49.16) v1(103.79,49.57) v1(103.89,49.31) v1(103.92,49.05) v1(104.38,49.49) v1(104.38,49.24) v1(104.63,49.49) v1(104.63,49.24) v1(112.43,38.94) v1(112.68,38.94) v1(112.91,34.13) v1(112.91,33.74) v1(113.04,47.63) v1(113.06,48.01) v1(113.22,47.81) v1(113.16,34.13) v1(113.16,33.87) v1(113.16,33.62) v1(113.95,36.66) v1(113.95,36.4) v1(114.21,36.66) v1(114.21,36.4) v2(104.38,49.49) v2(104.38,49.24) v2(104.63,49.49) v2(104.63,49.24) v2(112.43,38.94) v2(112.68,38.94) v2(112.91,34.13) v2(112.91,33.74) v2(113.04,47.63) v2(113.06,48.01) v2(113.22,47.81) v2(113.16,34.13) v2(113.16,33.87) v2(113.16,33.62) v2(113.95,36.66) v2(113.95,36.4) v2(114.13,45.45) v2(114.13,45.17) v2(114.13,44.89) v2(114.21,36.66) v2(114.21,36.4) v3(113.32,34.58) v3(113.62,36.71) v3(114.16,36.99)
PP5000_PMIC_N: length 238.2
  IN1 w0.076: v2(119.11,45.22) 119.26,45.36 119.26,45.62 118.45,46.42 118.45,47.91 116.34,50.02 113.55,50.02 113.08,49.54 105.66,49.54 105.09,50.11 103.4,50.11 102.54,49.25 100.8,49.25 100.71,49.34 100.36,49.34 100.28,49.27 100.28,48.81 100.29,48.81 v1(100.29,48.78)
  IN2 w0.076: v3(136.51,41.79) 136.23,42.07 134.96,42.07 134.76,42.27 129.35,42.27 127.7,43.92 125.14,43.92 124.56,44.51 123.19,44.51 122.98,44.3 120.7,44.3 120.29,44.71 119.45,44.71 119.26,44.89 119.26,45.07 v2(119.11,45.22) ; v3(125.36,66.94) 125.38,66.94 125.58,66.74 125.58,66.63 125.48,66.53 124.6,66.53 123.95,67.17 75.51,67.17 73.49,65.16 73.49,64.68 71.7,62.9 71.38,62.9 67.39,58.91 67.39,54.53 63.68,50.81 62.86,50.81 62.11,50.07 59.96,50.07 58.63,48.73 57.55,48.73 57.44,48.62 40.13,48.62 38.55,47.05 36.47,47.05 35.52,47.99 35.52,48.29 35.19,48.62 23.59,48.62 22.64,47.67 22.64,45.7 22.06,45.12 19.06,45.12 18.74,45.45 16.84,45.45 16.28,44.89 16.28,42.29 16.52,42.04 16.52,38.64 17.52,37.64 17.52,37.26 16.02,35.76 15.75,35.76 14.76,34.76 14.76,34.21 13.74,33.19 13.74,31.44 13.34,31.04 13.34,30.26 14.52,29.08 14.52,28.9 15.07,28.35 15.07,27.48 15.4,27.15 15.4,25.42 15.66,25.16 15.66,24.65 13.72,22.72 13.72,21.15 11.69,19.12 11.69,14.52 12.61,13.61 12.61,12.35 12.53,12.28 v2(12.3,12.28)
  IN3 w0.076: v3(136.51,41.79) 136.27,42.03 135,42.03 133.75,43.27 133.75,46.45 133.46,46.74 133.46,47.34 133.74,47.62 133.74,52.46 128.05,58.15 127.85,58.15 127.47,58.53 127.47,59.11 128.1,59.75 128.1,60.4 127.59,60.9 127.59,62.81 128.13,63.34 128.13,64.9 126.98,66.05 126.04,66.05 125.64,66.45 125.64,66.66 v3(125.36,66.94)
PP5000_PMIC_P: length 237.9
  IN1 w0.076: v2(119.57,45.22) 119.41,45.38 119.41,45.68 118.6,46.49 118.6,47.97 116.4,50.17 113.49,50.17 113.01,49.7 105.73,49.7 105.16,50.26 103.34,50.26 102.48,49.41 100.87,49.41 100.78,49.49 100.38,49.49 100.28,49.6 100.28,50.04 100.29,50.05 v1(100.29,50.08)
  IN2 w0.076: v2(119.57,45.22) 119.41,45.07 119.41,44.96 119.51,44.86 120.35,44.86 120.76,44.46 122.92,44.46 123.12,44.66 124.62,44.66 125.2,44.08 127.76,44.08 129.41,42.42 134.82,42.42 135.02,42.22 136.3,42.22 v3(136.51,42.42) ; v3(125.99,66.94) 125.73,66.67 125.73,66.57 125.54,66.38 124.53,66.38 123.89,67.02 75.57,67.02 73.64,65.09 73.64,64.62 71.77,62.74 71.45,62.74 67.55,58.85 67.55,54.46 63.74,50.66 62.92,50.66 62.18,49.91 60.03,49.91 58.69,48.58 57.62,48.58 57.5,48.47 40.19,48.47 38.62,46.89 36.41,46.89 35.37,47.93 35.37,48.22 35.13,48.47 23.65,48.47 22.79,47.61 22.79,45.63 22.13,44.97 19,44.97 18.67,45.29 16.9,45.29 16.43,44.82 16.43,42.35 16.68,42.1 16.68,38.7 17.68,37.7 17.68,37.19 16.09,35.61 15.82,35.61 14.91,34.7 14.91,34.14 13.89,33.12 13.89,31.38 13.5,30.98 13.5,30.32 14.67,29.14 14.67,28.96 15.22,28.41 15.22,27.54 15.55,27.21 15.55,25.48 15.81,25.23 15.81,24.59 13.88,22.66 13.88,21.09 11.84,19.06 11.84,14.59 12.76,13.67 12.76,12.35 12.84,12.28 v2(13.06,12.28)
  IN3 w0.076: v3(125.99,66.94) 125.79,66.73 125.79,66.52 126.11,66.2 127.05,66.2 128.28,64.97 128.28,63.28 127.74,62.74 127.74,60.97 128.25,60.46 128.25,59.68 127.62,59.05 127.62,58.59 127.91,58.3 128.11,58.3 133.89,52.52 133.89,47.55 133.61,47.28 133.61,46.81 133.9,46.51 133.9,43.34 135.06,42.18 136.27,42.18 v3(136.51,42.42)
PP5000_SMPS: length 3.4
  TOP w0.102: U2001.E2 105.19,35.61 105.19,35.59 104.59,34.99 104.59,34.25 104.73,34.11 C2001.1 105,34.09 R2001.2
PP5000_VCORE:
  vias: v1(102.14,47.35) v1(102.4,47.35) v1(102.65,47.35) v1(102.6,43.47) v1(102.78,43.64) v1(102.95,43.82) v2(102.14,47.35) v2(102.4,47.35) v2(102.65,47.35) v2(102.6,43.47) v2(102.78,43.64) v2(102.95,43.82)
PP5000_VDRAM1: length 1.4
  TOP w0.4: 107.7,43.37 107.7,42.63 107.22,42.16
  vias: v1(104.71,48.55) v1(104.66,48.3) v1(104.66,48.04) v1(106.71,44.14) v1(106.97,44.25) v1(106.97,44) v2(104.71,48.55) v2(104.66,48.3) v2(104.66,48.04) v2(106.71,44.14) v2(106.97,44.25) v2(106.97,44) v3(105.04,48.63) v3(104.96,48.17) v3(106.49,45.01) v3(106.89,44.99) v3(106.88,44.57)
PP5000_VDRAM1_N: length 36
  TOP w0.076: v2(107.14,50.56) 106.99,50.41 106.99,49.78 105.93,48.73 105.55,48.73 105.41,48.59 NC270.2
  IN2 w0.076: v3(117.2,31.86) 117.43,31.63 117.67,31.63 118.07,32.02 118.07,32.33 120,34.26 120,35.25 119.39,35.86 119.39,43.35 116.34,46.4 116.34,47.8 115.43,48.71 115.43,49.28 112.95,51.75 107.22,51.75 107,51.54 107,50.7 v2(107.14,50.56)
  IN4 w0.076: v3(117.2,31.86) 116.72,31.38 116.57,31.38 116.47,31.47 v5(116.47,31.65)
PP5000_VDRAM1_P: length 36.4
  TOP w0.076: v2(106.71,50.56) 106.84,50.43 106.84,49.84 105.87,48.88 105.52,48.88 105.41,48.99 NC271.2
  IN2 w0.076: v2(106.71,50.56) 106.85,50.7 106.85,51.6 107.15,51.91 113.02,51.91 115.58,49.35 115.58,48.77 116.49,47.87 116.49,46.47 119.54,43.41 119.54,35.92 120.15,35.31 120.15,34.19 118.22,32.26 118.22,31.96 117.74,31.48 117.43,31.48 v3(117.2,31.25)
  IN4 w0.076: v5(116.47,30.94) 116.47,31.12 116.57,31.22 117.18,31.22 v3(117.2,31.25)
PP5000_VGPU: length 1.2
  TOP w0.254: U2001.B11 U2001.A11 103.7,39.65 103.36,39.99
  vias: v1(98.18,41.16) v1(98.15,40.9) v1(102.68,40) v1(102.94,40.01) v1(103.2,40.01) v2(98.18,41.16) v2(98.15,40.9) v2(102.68,40) v2(102.94,40.01) v2(103.2,40.01)
PP5000_VMODEM:
  vias: v1(105.7,44.05) v1(105.7,43.8) v1(105.7,43.54) v1(106.02,40.85)
PP5000_VPROC11: length 0.8
  TOP w0.254: U2001.B6 U2001.A6 103.77,37.65 103.64,37.52
  vias: v1(97.87,37.76) v1(97.87,37.5) v1(98.13,37.88) v1(98.13,37.63) v1(98.13,37.38) v1(98.13,37.12) v1(102.65,37.17) v1(102.9,37.17) v1(103.16,37.17) v2(97.87,37.76) v2(97.87,37.5) v2(98.13,37.88) v2(98.13,37.63) v2(98.13,37.38) v2(98.13,37.12) v2(102.65,37.17) v2(102.9,37.17) v2(103.16,37.17)
PP5000_VPROC12: length 1.1
  TOP w0.254: 103.31,39.25 U2001.A10 U2001.B10
  vias: v1(97.87,38.32) v1(98,38.54) v1(98.08,39.13) v1(98.08,38.87) v1(98.13,38.32) v1(102.67,39.6) v1(102.93,39.6) v1(103.18,39.6) v2(97.87,38.32) v2(98,38.54) v2(98.08,39.13) v2(98.08,38.87) v2(98.13,38.32) v2(102.67,39.6) v2(102.93,39.6) v2(103.18,39.6)
PP5000_VS1:
  vias: v1(104.2,34.75) v1(104.2,34.5) v1(104.2,34.25) v1(105.64,33.08) v1(105.64,32.82) v2(104.2,34.75) v2(104.2,34.5) v2(104.2,34.25) v2(105.64,33.08) v2(105.64,32.82) v3(103.49,34.72) v3(103.49,34.24) v3(105.29,33.08)
PP5000_VS2: length 6.5
  TOP w0.254: U2001.K15 U2001.K16 107.62,41.87
  TOP w0.4: C2024.1 108.36,42.64 107.62,41.9 107.62,41.87
  IN2 w0.508: 108.85,47.28 108.85,45.61 109.22,45.23 109.22,43.79 108.69,43.26 108.69,43.17
  vias: v1(108.21,43.04) v1(108.21,42.79) v1(108.8,48.75) v1(109.1,48.75) v2(108.21,43.04) v2(108.21,42.79) v2(108.8,48.75) v2(109.1,48.75)
PPVAR_BATT: length 49.7
  TOP w0.254: R90842.2 121.59,29.57 121.83,29.8 v6(122.03,29.8)
  TOP w0.508: v6(93.07,12.45) 93.61,12.99 98.41,12.99 99.04,12.35 99.04,11.69 100.54,10.19 111.07,10.19 v6(111.82,9.44)
  IN4 w0.508: v6(111.82,9.44) 112.06,9.2 117.26,9.2 118.46,10.41 118.46,10.74 119.21,11.49 119.21,17.61 121.52,19.92 121.52,29.29 v6(122.03,29.8)
PPVAR_PWR_IN: length 119
  TOP w0.203: R90836.1 37.1,45.82 36.66,46.26 36.47,46.26 R654.1
  IN4 w0.203: v5(67.95,50.32) 67.64,50.64 65.19,50.64 64.24,49.69 63.47,49.69 61.29,47.5 59.6,47.5 58.38,46.28 56.73,46.28 55.53,47.48 43.29,47.48 41.57,45.75 37.45,45.75 v6(36.51,44.81)
  BOTTOM w0.203: R2304.1 113.39,43.14 113.88,43.63 R2302.1 113.88,45.15 115.22,46.49 117.08,46.49 117.97,47.38 117.97,50.81 121.12,53.97 121.12,54.84 120.46,55.51 114.48,55.51 106.57,63.42 77.19,63.42 72.59,58.81 72.59,57.55 72.21,57.17 72.21,52.04 71.94,51.77 71.28,51.77 69.99,50.48 69.15,50.48 68.84,50.17 68.05,50.17 67.95,50.27 v5(67.95,50.32)
PPVAR_PWR_IN_BB: length 1.4
  TOP w0.203: R654.2 36.05,46.77 36.2,46.62 36.81,46.62 36.94,46.49 R90837.1
  vias: v6(36.41,48.34) v6(36.81,47.71) v6(37.14,48.34) v6(37.52,47.71) v6(37.85,48.34) v6(38.57,48.29) v6(120.38,37.37) v6(120.53,38.79) v6(120.53,38.08) v6(121.09,37.37) v6(121.24,38.79) v6(121.24,38.08) v6(121.95,38.79) v6(121.95,38.08)
PPVAR_SYS: length 77.8
  TOP w0.203: v1(121.5,27.37) 121.4,27.47 R91194.2
  TOP w0.762: 99.75,16.31 99.83,16.24 99.83,12.02 100.87,10.98 111.97,10.98 114.08,8.87 117.03,8.87 118.85,10.7 120.66,10.7 122.64,12.68 124.67,12.68 125.08,13.09 126.6,13.09 126.96,13.44 126.96,16.68 125.94,17.69 125.94,22.46 127.77,24.29 v6(130.01,24.29)
  IN1 w0.254: v1(121.5,27.37) 121.5,25.58 121.01,25.1 121.01,19.72 121.55,19.18 125.97,19.18 127.11,20.33 127.11,21.72 129.68,24.29 v6(130.01,24.29)
  IN2 w0.762: v6(133.16,31.35) 133.16,27.44 v6(130.01,24.29)
  vias: v6(79.56,16.9) v6(79.94,16.26) v6(80.27,16.9) v6(80.65,16.26) v6(80.98,16.9) v6(81.36,16.26) v6(81.69,16.9) v6(82.43,16.9) v6(83.14,16.9) v6(83.85,16.9) v6(102.57,19.95) v6(102.93,19.31) v6(103.28,19.95) v6(103.28,18.68) v6(103.64,19.31) v6(104,19.95) v6(104,18.68) v6(104.35,19.31) v6(104.71,19.95) v6(104.78,18.73)
PPVAR_SYS_BL_N: length 32.9
  TOP w0.076: R443.1 36.13,29.36 36.13,29.93 39.86,33.66 45.33,33.66 46.15,34.48 50.63,34.48 51.81,35.67 56.07,35.67 57.69,37.29 57.69,40.87 v6(57.48,41.09)
  BOTTOM w0.076: NC302.2 58.84,39.06 58.77,39 58.62,39 58.53,39.08 58.53,39.88 57.48,40.94 v6(57.48,41.09)
