# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
PP3300_ALW on TOP (solid shape): 48.24,8.01 49.31,8.01 49.54,7.78 49.54,7.52 49.26,7.25 45.45,7.25 45.39,7.26 45.35,7.27 45.04,7.27 45,7.26 44.94,7.25 44.43,7.25 44.38,7.26 44.33,7.27 44.03,7.27 43.98,7.26 43.93,7.25 43.85,7.25 43.47,6.86 42.86,6.86 42.78,6.94 42.78,8.03 42.89,8.14 48.11,8.14
PP3300_ALW on TOP (solid shape): 51.49,12.1 53.83,12.1 53.98,11.94 53.98,11.51 53.81,11.34 53.77,11.35 53.39,11.35 53.3,11.33 53.25,11.26 53.17,11.18 53.17,10.01 52.42,9.26 51.61,9.26 51.57,9.23 50.02,9.23 49.87,9.38 49.87,10.45 49.72,10.6 48.42,10.6 48.22,10.8 48.22,11.33 48.27,11.39 48.42,11.39 48.88,11.84 48.88,12.22 49.06,12.4 49.07,12.4 49.4,12.73 50.86,12.73
PP3300_ALW on TOP (solid shape): 144.58,23.65 144.58,22.11 144.96,21.74 145.08,21.34 145.24,20.95 145.24,20.74 145.48,20.5 145.95,19.86 146.53,19.31 146.53,18.45 146.49,18.41 146.05,18.41 145.95,18.52 145.95,19.16 144.63,20.47 144.14,20.47 144.04,20.56 144.04,21.21 144.18,21.34 144.23,21.34 144.5,21.57 144.32,21.88 144.04,22.16 144.04,23.55 144.19,23.71 144.53,23.71
PP3300_ALW on TOP (solid shape): outline of 83 points within 70.44,2.34 133.59,15.33
PP3300_ALW on BOTTOM (solid shape): outline of 2712 points within 4.77,2.03 74.48,43.1
PP3300_ALW on IN2 (solid shape): 51.03,12.65 51.03,12.27 49.83,11.07 49.83,9.22 49.03,8.42 49.03,7.65 48.67,7.3 48.32,7.3 48.3,7.32 48.3,10.8 48.44,10.8 48.45,10.74 48.46,10.69 48.48,10.64 48.51,10.59 48.54,10.54 48.58,10.5 48.62,10.46 48.67,10.43 48.73,10.41 48.78,10.4 48.84,10.39 48.9,10.4 48.95,10.41 49.01,10.42 49.06,10.45 49.1,10.48 49.15,10.52 49.18,10.56 49.21,10.61 49.24,10.66 49.25,10.72 49.26,10.77 49.26,10.83 49.25,10.89 49.24,10.94 49.21,10.99 49.18,11.04 49.15,11.08 49.1,11.12 49.06,11.15 49.01,11.18 48.95,11.2 48.9,11.21 48.84,11.21 48.78,11.2 48.73,11.19 48.67,11.17 48.62,11.14 48.58,11.1 48.54,11.06 48.51,11.02 48.48,10.97 48.46,10.91 48.45,10.86 48.44,10.8 48.3,10.8 48.3,11.87 49.18,12.76 50.93,12.76
PP3300_CAM on BOTTOM (solid shape): 40.2,35.5 40.4,35.5 40.4,36.79 40.67,36.79 40.7,36.76 40.7,35.6 40.7,35.4 40.74,35.4 40.74,35.25 40.87,35.25 41.14,34.98 41.14,34.97 41.34,34.84 41.56,34.9 41.97,34.9 42.15,34.83 42.33,34.9 42.36,34.9 42.61,34.64 42.61,33.72 42.55,33.66 41.54,33.66 41.49,33.68 41.45,33.69 41.38,33.69 41.31,33.71 41.26,33.71 41.21,33.71 41.15,33.69 41.07,33.69 41.03,33.68 40.98,33.66 40.17,33.66 39.86,33.97 39.86,35.4 39.9,35.4 39.9,36.68 40,36.79 40.2,36.79
PP3300_CTP on BOTTOM (solid shape): 54.24,37.57 54.24,35.06 54.11,34.93 53.95,34.87 53.82,34.75 51.32,34.75 51.08,34.51 48.1,34.51 48.01,34.6 47.3,34.6 47.06,34.36 47.06,33.17 46.95,33.05 45.9,33.05 45.88,33.06 45.84,33.09 45.79,33.09 45.41,33.09 45.39,33.09 45.31,33.12 45.27,33.19 45.27,34.98 45.53,35.24 50.75,35.24 50.77,35.25 50.9,35.38 50.9,35.56 50.91,35.57 50.91,36.7 51.19,36.7 51.19,35.34 51.27,35.26 53.75,35.26 53.85,35.36 53.85,37.35 53.4,37.8 53.27,37.8 53.12,37.95 53.12,38.21 53.2,38.28 53.53,38.28
PP3300_CTP on IN1 (solid shape): 51.44,47.69 51.44,47.09 51.63,46.9 51.69,46.9 51.75,46.88 51.8,46.87 51.85,46.88 51.91,46.9 53.36,46.9 53.89,47.42 55.85,47.42 55.95,47.33 55.95,47.23 55.94,47.19 55.95,47.08 55.74,46.87 54.04,46.87 53.56,46.39 51.5,46.39 51,46.89 51,47.29 50.92,47.37 49.56,47.37 49.21,47.02 47.17,47.02 46.37,46.22 43.72,46.22 43.69,46.25 43.69,46.61 43.74,46.66 43.81,46.67 43.86,46.68 44.52,46.68 44.57,46.67 44.61,46.66 44.65,46.67 44.7,46.68 46.21,46.68 46.99,47.45 48.98,47.45 49.33,47.79 51.34,47.79
PP3300_EC on TOP (solid shape): 131.22,54.21 131.28,54.18 131.35,54.16 131.98,54.16 132.19,53.96 132.19,53.35 132.06,53.22 131.3,53.22 130.92,52.84 130.92,52.58 130.84,52.5 130.12,52.5 130.03,52.58 130.03,53.73 130.15,53.84 130.22,53.82 130.6,53.82 130.63,53.83 130.71,53.85 130.79,53.85 131.15,54.21 131.17,54.22 131.18,54.22
PP3300_EDP_DX on TOP (solid shape): 47.13,39.96 47.13,39.43 47.63,38.92 47.63,37.83 47.53,37.73 46.07,37.73 46.07,38.16 45.22,39.01 45.22,39.3 45.37,39.45 45.37,39.94 45.51,40.08 47.01,40.08
PP3300_EDP_DX on BOTTOM (solid shape): 48.22,37.42 48.22,36.9 48.2,36.9 48.2,35.49 47.9,35.49 47.9,36.8 47.7,36.8 47.7,35.49 47.4,35.49 47.4,36.8 47.2,36.8 47.2,35.49 46.9,35.49 46.9,36.9 46.9,36.99 46.34,37.55 46.34,38.16 46.41,38.23 47.4,38.23
PP3300_EDP_DX_R on TOP (solid shape): 45.88,43.59 46.69,43.59 46.87,43.41 46.87,40.67 46.65,40.45 45.42,40.45 45.39,40.45 45.36,40.48 45.36,41.13 45.09,41.41 42.3,41.41 42.22,41.48 42.22,43.62 42.27,43.67 45.8,43.67
PP3300_H1 on TOP (solid shape): outline of 111 points within 49.92,3.17 56.88,20.25
PP3300_H1 on IN1 (solid shape): outline of 235 points within 50.35,14.76 54.19,18.55
PP3300_H1 on IN2 (solid shape): 54.22,16.65 54.34,16.55 54.49,16.52 54.63,16.54 54.74,16.62 54.92,16.62 54.95,16.62 56.71,16.62 57.19,16.14 57.19,16.06 57.19,16.02 57.2,15.98 57.2,15.37 57.55,15.02 57.55,14.84 57.43,14.72 57.2,14.72 56.73,15.2 56.73,15.77 56.75,15.84 56.76,15.9 56.68,16.1 56.48,16.18 56.46,16.18 56.28,16.36 55.24,16.36 55.06,16.19 54.55,16.19 54.07,15.71 53.85,15.71 53.37,15.23 53.36,15.23 53.18,15.1 53.12,14.89 53.15,14.74 53.25,14.62 53.25,14.28 53.17,14.2 52.96,14.2 52.66,14.5 52.66,15.07 52.81,15.22 52.98,15.28 53.08,15.43 53.09,15.44 53.2,15.55 53.2,15.73 54.13,16.66 54.2,16.66
PP3300_H1_EC on TOP (solid shape): 58.28,11.82 58.34,11.77 58.42,11.76 60.22,11.76 60.29,11.77 60.36,11.82 60.64,12.1 61.78,12.1 61.83,12.05 61.83,11.12 61.67,10.96 60.46,10.96 60.34,11.04 60.2,11.07 57.02,11.07 56.96,11.14 56.96,12.15 57.06,12.25 57.84,12.25
PP3300_H1_EC on TOP (solid shape): 73.82,11.74 73.82,11.33 73.72,11.23 73.72,9.68 73.82,9.58 73.82,7.88 73.31,7.37 73.31,6.31 72.04,5.04 70.57,5.04 70.47,4.93 70.16,4.93 70.01,5.08 70.01,6.71 70.16,6.86 71.51,6.86 71.6,6.96 71.6,7.44 72.3,8.14 72.3,8.59 71.48,9.4 71.48,9.42 72.52,9.42 72.53,9.38 72.53,9.33 72.55,9.27 72.57,9.22 72.61,9.17 72.64,9.12 72.69,9.09 72.74,9.05 72.79,9.03 72.85,9.01 72.9,9.01 72.96,9.01 73.02,9.01 73.07,9.03 73.13,9.05 73.18,9.09 73.22,9.12 73.26,9.17 73.29,9.22 73.31,9.27 73.33,9.33 73.34,9.38 73.34,9.45 73.33,9.5 73.31,9.56 73.29,9.61 73.26,9.66 73.22,9.71 73.18,9.74 73.13,9.77 73.07,9.8 73.02,9.82 72.96,9.82 72.9,9.82 72.85,9.82 72.79,9.8 72.74,9.77 72.69,9.74 72.64,9.71 72.61,9.66 72.57,9.61 72.55,9.56 72.53,9.5 72.53,9.45 72.52,9.42 71.48,9.42 71.48,12.15 71.69,12.35 73.21,12.35
PP3300_H1_EC on IN2 (solid shape): 64.79,13.1 64.79,11.87 64.66,11.74 63.29,11.74 63.3,11.79 63.31,11.84 62.85,12.3 62.39,11.84 62.39,11.81 62.36,11.81 62.29,11.82 62.26,11.82 61.04,11.82 60.92,11.94 60.92,12.03 61.07,12.16 61.12,12.35 61.11,12.44 61.94,13.26 64.62,13.26
PP3300_HUB on TOP (solid shape): 65.08,27.69 66.28,27.69 66.28,27.44 64.27,27.44 64.19,27.51 64.19,27.69 64.5,28 64.78,28
PP3300_HUB on TOP (solid shape): outline of 129 points within 62.94,22.21 73.37,33.12
PP3300_INA on TOP (solid shape): 43.32,26.78 43.32,26.24 43.21,26.14 42.07,26.14 41.46,25.53 40.7,25.53 40.6,25.63 40.6,26.75 40.67,26.83 43.26,26.83
PP3300_INA on TOP (solid shape): 55.03,40.98 55.03,40.11 54.5,39.58 54.5,39.05 54.43,38.98 54.18,38.98 53.42,39.74 53.42,41.21 53.45,41.24 54.77,41.24
PP3300_INA on TOP (solid shape): 42.6,30.61 42.6,29.19 42.4,28.99 41.38,28.99 41.31,29.06 41.31,29.42 41.08,29.65 40.67,29.65 40.62,29.7 40.62,30.77 40.78,30.92 42.3,30.92
PP3300_INA on TOP (solid shape): 129.7,66.05 129.7,59.65 129.32,59.26 127.23,59.26 126.8,59.69 126.8,60.28 128.38,61.86 128.38,66.1 128.58,66.3 129.45,66.3
PP3300_INA on TOP (solid shape): 126.07,14.51 126.07,13.99 126.01,13.9 125.99,13.8 125.99,13.78 125.84,13.62 124.86,13.62 124.45,13.21 122.83,13.21 122.82,13.21 122.28,13.21 122.16,13.34 122.16,14.61 125.97,14.61
PP3300_INA on TOP (solid shape): 62.19,47.63 62.19,45.93 61.29,45.04 60.63,45.04 60.34,44.74 60.34,44.59 60.21,44.46 60.21,43.85 60.05,43.69 60.05,39.14 60.02,39.11 60.02,34.92 58.07,32.98 56.22,32.98 56.05,33.14 56.05,34.09 58.57,36.61 58.57,43.52 58.1,44 58.1,44.99 60.16,47.05 60.36,47.05 61.1,47.78 62.04,47.78
PP3300_INA on TOP (solid shape): 122.28,24.77 122.28,22.1 122.54,21.85 124.06,21.85 124.7,21.22 124.7,16.9 124.57,16.77 122.92,16.77 122.82,16.87 122.82,16.96 122.79,16.99 122.79,17.15 122.92,17.28 123.55,17.28 123.68,17.41 123.68,19.06 123.93,19.31 123.93,20.96 123.68,21.22 122.03,21.22 121.52,21.72 121.52,24.78 121.64,24.9 122.16,24.9
PP3300_INA on TOP (solid shape): 42.5,23.42 42.5,13.21 42.4,13.11 37.47,13.11 37.22,12.86 37.22,12.05 37.07,11.89 36.53,11.89 36.3,11.66 24.42,11.66 23.88,11.13 23.06,11.13 22.97,11.13 20.25,8.41 14.57,8.41 11.31,11.67 11.31,15.19 10.73,15.76 10.73,16.09 10.79,16.15 11.8,16.15 11.88,16.07 11.88,12.03 12.03,11.88 13.27,11.88 13.48,12.09 13.48,12.84 13.88,13.25 13.88,14.08 14.06,14.26 14.06,15.48 14.12,15.54 14.45,15.54 14.49,15.5 14.49,13.96 14.44,13.91 14.44,12.03 14.49,11.98 14.49,10.18 14.6,10.07 14.72,9.96 17.07,9.96 17.17,9.86 19.47,9.86 20.74,11.12 21.08,11.12 21.24,11.15 21.37,11.24 23.72,13.59 33.05,13.59 33.21,13.62 33.34,13.7 33.51,13.7 34.83,15.02 40.37,15.02 40.7,15.35 40.7,22.61 40.32,22.99 39.12,22.99 39.07,23.04 39.07,23.91 39.18,24.01 41.92,24.01
PP3300_INA on BOTTOM (solid shape): 125.33,61.25 125.33,60.64 125.43,60.54 125.43,60.53 125.48,60.45 125.58,60.41 126.92,60.41 126.96,60.42 127,60.43 127.53,60.43 128.17,59.79 129.05,59.79 129.23,59.62 129.23,57.15 129.19,57.11 128.96,57.11 128.92,57.16 128.92,57.46 128,58.37 128,58.42 128.01,58.45 128.01,58.48 128.01,58.86 127.97,58.97 127.86,59.01 127.78,59.01 127.73,59.03 127.67,59.04 127.61,59.03 127.56,59.01 127.48,59.01 127.43,59.01 127.39,58.99 127.16,59.21 124.82,59.21 124.72,59.32 124.72,60.94 124.42,61.25 123.1,61.25 123,61.35 123,61.55 123.1,61.65 124.93,61.65
PP3300_INA on BOTTOM (solid shape): 111.37,67.44 111.46,67.38 111.44,67.27 110.96,66.78 110.96,65.87 111.62,65.21 112.53,65.21 113.19,65.87 113.19,66.78 112.7,67.27 112.68,67.38 112.78,67.44 129.6,67.44 129.75,67.29 129.75,65.39 129.65,65.28 128.38,65.28 128.25,65.41 128.25,66.15 128.04,66.36 117.26,66.36 117.1,66.2 115.95,66.2 115.91,66.31 115.8,66.35 114.6,66.35 114.49,66.31 114.45,66.2 114.45,63.84 114.02,63.41 110.78,63.41 108.82,65.36 73.62,65.36 72.65,66.33 72.51,66.77 72.27,67.17 72.27,67.21 72.5,67.44
PP3300_INA on IN1 (solid shape): 58.48,44.35 58.48,43.95 58.08,43.55 57.02,43.55 55.67,42.21 55.67,42.16 55.61,42.09 55.61,40.77 55.2,40.37 54.42,40.37 54.39,40.39 54.39,42.68 54.39,42.7 54.4,42.73 54.59,42.81 54.66,43 54.6,43.18 54.43,43.28 54.39,43.28 54.39,43.97 54.87,44.46 58.38,44.46
PP3300_INA on IN1 (solid shape): 57.36,33.48 57.36,32.26 57.16,32.06 48.73,32.06 47.12,30.45 43.82,30.45 43.71,30.56 43.71,31.33 44.02,31.64 46.19,31.64 46.21,31.67 46.23,31.67 46.28,31.7 46.32,31.73 46.35,31.77 46.38,31.82 46.38,31.84 47,32.45 47,32.96 48.78,32.96 48.78,32.91 48.79,32.87 48.81,32.82 48.84,32.78 48.87,32.75 48.91,32.72 48.95,32.7 49,32.69 49.04,32.68 49.09,32.68 49.14,32.69 49.18,32.71 49.22,32.73 49.26,32.77 49.29,32.8 49.31,32.84 49.33,32.89 49.33,32.94 49.33,32.98 49.33,33.03 49.31,33.07 49.29,33.11 49.26,33.15 49.22,33.18 49.18,33.21 49.14,33.23 49.09,33.24 49.04,33.24 49,33.23 48.95,33.22 48.91,33.2 48.87,33.17 48.84,33.13 48.81,33.09 48.79,33.05 48.78,33.01 48.78,32.96 47,32.96 47,33.28 47.3,33.58 57.26,33.58
PP3300_INA on IN1 (solid shape): 74.38,67.11 74.38,61.52 69.88,57.03 69.88,56.92 69.86,56.89 69.86,56.81 69.86,54.34 67.28,51.76 67.28,51.27 66.2,50.19 66.04,50.19 65.95,50.25 65.85,50.27 65.65,50.19 65.57,49.99 65.59,49.88 65.66,49.78 65.66,49.65 64.35,48.34 63.99,48.34 63.85,48.2 63.78,48.17 63.71,48.2 63.63,48.25 63.53,48.26 63.34,48.19 63.26,48 63.22,47.93 63.15,47.91 63.13,47.91 62.93,47.83 62.85,47.63 62.85,47.59 62.87,47.53 62.56,47.22 61.53,47.22 61.45,47.3 61.45,47.96 61.46,47.97 61.46,48.81 61.71,49.06 62.55,49.06 68.77,55.28 68.77,57.87 72.68,61.78 72.68,62.15 72.75,62.34 72.68,62.53 72.68,64.92 72.68,65 72.68,66 72.68,66.08 72.68,67.24 72.83,67.39 74.1,67.39
PP3300_INA on IN1 (solid shape): outline of 179 points within 120.96,24.44 130.04,44.05
PP3300_INA on IN2 (solid shape): 127.3,14.04 127.3,13.51 126.84,13.05 125.35,13.05 124.95,13.44 124.95,13.76 125.25,14.06 125.88,14.06 125.97,13.98 125.97,13.68 126.11,13.53 126.18,13.53 126.23,13.52 126.27,13.52 126.31,13.52 126.36,13.53 126.41,13.53 126.98,14.1 127.24,14.1
PP3300_INA on IN2 (solid shape): outline of 218 points within 124.62,43.34 132.14,60.35
PP3300_INA on IN2 (solid shape): outline of 319 points within 38.13,23.43 44.35,31.03
PP3300_KBC on TOP (solid shape): 145.86,18.34 145.86,18.07 147.32,18.07 147.46,17.94 147.46,17.46 147.3,17.3 146.69,17.3 146.65,17.3 145.37,17.3 144.74,17.94 144.69,17.94 144.63,17.95 144.59,17.96 144.54,17.95 144.48,17.94 144.3,17.94 144.3,17.98 143.28,17.98 143.27,17.98 143.21,18.04 143.21,18.34 143.32,18.45 145.75,18.45
PP3300_KBC on IN3 (solid shape): 135.81,18.48 135.81,14.8 135.31,14.31 135.29,14.3 135.03,14.19 134.91,13.92 134.91,13.9 134.86,13.85 134.86,12.33 135.24,11.94 137.97,11.94 137.97,11.94 140.06,11.94 140.17,11.83 140.17,11.25 140.11,11.16 140.01,11.16 139.92,11.2 139.81,11.21 139.52,11.09 139.4,10.8 139.42,10.69 139.47,10.58 139.48,10.47 139.39,10.42 138.77,10.42 138.76,10.42 134.09,10.42 133.84,10.67 133.84,17.53 135.11,18.8 135.49,18.8
PP3300_KBC on IN4 (solid shape): 140.06,11.69 140.06,11.26 140.03,11.22 139.54,11.22 139.33,11 139.33,10.57 139.17,10.42 138.54,10.42 138.46,10.5 138.46,11.66 138.67,11.87 139.89,11.87
PP3300_MIPIBRDG_DX on TOP (solid shape): 48.22,44.48 48.22,42.75 48.09,42.63 47.23,42.63 47.07,42.78 47.07,43.43 47.05,43.45 47.05,43.52 46.74,43.82 45.98,43.82 45.91,43.9 45.91,44.51 46.06,44.66 48.04,44.66
PP3300_MIPIBRDG_DX on TOP (solid shape): 54.2,38.47 55.19,38.47 55.35,38.31 55.35,37.93 55.25,37.83 54.49,37.83 54.48,37.84 53.41,37.84 53.2,38.06 51.93,38.06 51.75,38.23 51.75,38.94 51.88,39.07 53.6,39.07
PP3300_MIPIBRDG_DX on IN2 (solid shape): outline of 1093 points within 38.57,37.22 62.85,44.47
PP3300_MIPIBRDG_DX on IN4 (solid shape): 63.81,42.88 63.81,42.83 63.9,42.6 64.11,42.48 64.13,42.48 64.15,42.45 64.25,42.45 64.58,42.12 64.58,41.54 64.5,41.48 64.44,41.4 64.27,41.23 63.87,41.23 63.61,41.49 63.51,41.49 63.5,41.52 63.37,41.66 63.18,41.71 62.93,41.61 62.82,41.36 62.82,41.33 62.79,41.26 62.72,41.23 62.49,41.23 62.41,41.22 62.33,41.19 62.32,41.19 61.92,41.19 61.7,41.41 61.7,41.97 62.72,42.98 63.71,42.98
PP3300_S3 on TOP (solid shape): 134.35,22.74 134.35,21.22 134.01,20.88 131.26,20.88 131.17,20.96 131.17,22.74 131.28,22.84 134.25,22.84
PP3300_S3 on TOP (solid shape): 123.71,64.27 123.71,63.38 123.16,62.84 120.72,62.84 120.54,63.01 120.54,63.85 121.12,64.43 123.54,64.43
PP3300_S3 on TOP (solid shape): 132.67,57.33 132.67,56.42 132.68,56.37 132.7,56.31 132.7,55.76 132.32,55.38 131.81,55.38 131.81,56.32 131.48,56.65 131.48,57.64 131.53,57.69 132.32,57.69
PP3300_S3 on TOP (solid shape): 62.6,32.11 62.6,31.38 62.41,31.19 62.36,31.2 62.21,31.18 62.12,31.15 61.68,31.15 61.63,31.2 61.63,32.09 61.73,32.19 62.53,32.19
PP3300_S3 on BOTTOM (solid shape): 46,48.25 46,43.78 45.63,43.41 42.24,43.41 41.92,43.73 41.92,48.14 42.58,48.8 45.45,48.8
PP3300_S3 on BOTTOM (solid shape): 122.77,63.94 122.77,62.92 122.51,62.67 120.4,62.67 120.23,62.85 120.23,63.94 120.35,64.06 122.64,64.06
PP3300_S3 on BOTTOM (solid shape): 44.81,34.88 44.81,33.09 44.73,33.09 44.34,33.09 44.27,33.08 44.22,33.03 43.92,33.03 43.67,32.77 43.32,32.77 43.26,32.82 43.26,33.36 42.95,33.67 42.95,34.75 43.16,34.96 44.74,34.96
PP3300_S3 on BOTTOM (solid shape): 69.22,63.99 69.9,63.35 70.8,63.12 71.03,63.14 71.26,63.18 71.31,63.14 71.33,63.08 71.33,58.85 70.59,58.11 70.59,57.68 70.59,57.66 70.59,53.36 65.88,48.65 59.65,48.65 59.58,48.71 59.58,50.3 60.05,51 60.37,51.77 61.12,51.77 61.15,51.77 61.68,51.67 62.22,51.64 62.55,51.65 62.88,51.69 62.97,51.7 63.06,51.72 63,51.6 62.97,51.47 63.38,51.06 63.79,51.47 63.72,51.69 63.55,51.84 65.85,53.47 66.74,56.16 66.53,57.52 65.92,58.75 65.92,61.11 67.38,62.32 68.28,63.99
PP3300_S3 on IN2 (solid shape): 62.04,32.26 62.04,31.35 61.73,31.05 61.4,31.05 60.86,30.51 60.36,30.51 58.3,28.45 51.21,28.45 50.99,28.68 50.99,29.75 51.21,29.98 56.07,29.98 58.25,32.16 60.31,32.16 60.51,32.36 61.94,32.36
PP3300_S3 on IN3 (solid shape): outline of 99 points within 43.21,28.4 52.84,33.55
PP3300_S3 on IN3 (solid shape): outline of 470 points within 41.69,43.67 62.67,51.97
PP3300_S3 on IN4 (solid shape): 44.64,34.32 44.64,33.02 44.36,32.74 43.32,32.74 43.24,32.82 43.24,34.02 43.62,34.4 44.56,34.4
PP3300_S3 on IN4 (solid shape): 45.36,43.83 45.36,43.28 45.02,42.94 42.24,42.94 42.12,43.05 42.12,43.92 42.29,44.09 43.14,44.09 43.19,44.08 43.24,44.07 43.29,44.08 43.34,44.09 45.1,44.09
PP3300_S3 on IN5 (solid shape): outline of 764 points within 41.89,33.15 56.63,43.82
PP3300_S3 on IN5 (solid shape): outline of 1680 points within 67.42,20.58 137.9,67.47
PP3300_TPAD on BOTTOM (solid shape): 55.29,9.71 55.29,6.54 55.1,6.34 54.74,6.34 54.44,6.64 54.44,7.56 53.11,8.9 53.11,9.53 53.19,9.62 53.51,9.62 53.6,9.65 53.66,9.72 55.29,9.72
PP3300_WLAN on BOTTOM (solid shape): 148.08,49.36 148.08,48.84 148.06,48.82 148.06,47.89 148.01,47.83 147.3,47.83 147.25,47.89 147.25,49.38 147.3,49.43 148,49.43
PP3300_WLAN on BOTTOM (solid shape): 147.96,60.89 148.11,60.89 148.24,60.75 148.24,60.46 148.04,60.26 148.04,60.13 148.04,60.13 148.04,59.32 147.23,59.32 147.23,60.25 146.95,60.53 146.95,60.75 147.09,60.89 147.96,60.89
PP3300_WLAN on IN4 (solid shape): outline of 2220 points within 128.68,44.58 148.83,63.28
PP5000_ALW on TOP (solid shape): 102.37,50.88 102.45,50.88 102.68,50.65 102.68,50.15 102.28,49.75 100.81,49.75 100.79,49.77 100.79,50.86 100.82,50.89 102.36,50.89
PP5000_ALW on TOP (solid shape): 34.1,46.23 34.1,45.85 34.27,45.68 34.27,45.01 34.4,44.89 34.83,44.89 34.96,44.76 34.96,43.97 34.45,43.47 33.18,43.47 32.85,43.8 32.85,46.23 33,46.39 33.94,46.39
PP5000_ALW on BOTTOM (solid shape): 34.91,44.94 34.91,43.59 34.6,43.29 30.92,43.29 30.65,43.02 30.65,40.91 30.51,40.77 29.24,40.77 29.12,40.9 29.12,44.63 29.57,45.09 34.76,45.09
PP5000_ALW on BOTTOM (solid shape): 78.75,17.71 78.75,16.16 78.52,15.93 76.46,15.93 76.17,16.22 76.17,17.91 76.27,17.91 76.38,17.96 76.42,18.07 76.42,18.71 76.64,18.93 77.53,18.93
PP5000_ALW on BOTTOM (solid shape): 136.23,44.81 136.23,42.53 136.08,42.37 129.27,42.37 129.17,42.47 115.59,42.47 115.4,42.66 115.4,44.25 115.6,44.46 115.79,44.53 115.88,44.72 115.88,44.74 116.1,44.95 121.64,44.95 121.65,44.96 136.08,44.96
PP5000_ALW on IN2 (solid shape): 102.57,50.68 102.57,49.92 102.32,49.68 102.25,49.62 102.19,49.55 101.86,49.22 100.58,49.22 100.47,49.33 100.47,50.5 100.71,50.75 102.51,50.75
PP5000_ALW on IN4 (solid shape): 102.57,51.06 102.57,49.98 101.86,49.26 100.53,49.26 100.22,49.57 100.22,50.84 100.64,51.25 102.38,51.25
PP5000_ALW on IN5 (solid shape): outline of 6089 points within 13.95,2.03 119.87,53.98
PP5000_PMIC on TOP (solid shape): 97.64,41.71 97.64,41.53 97.52,41.41 97.52,40.8 97.6,40.72 97.86,40.72 97.95,40.63 98.08,40.63 98.19,40.52 98.19,39.47 98.15,39.43 97.65,39.43 97.54,39.33 97.54,36.43 98.45,35.52 99.17,35.52 99.33,35.36 99.33,34.67 99.24,34.58 97.51,34.58 96.91,35.19 96.91,41.64 97.06,41.79 97.57,41.79
PP5000_PMIC on TOP (solid shape): 114.53,34.03 114.57,33.97 114.62,33.93 114.69,33.86 115.1,33.86 115.34,33.62 115.57,33.62 115.91,33.28 115.91,28.91 115.09,28.09 109.01,28.09 108.71,28.4 107.96,28.4 107.86,28.5 107.86,28.84 107.96,28.94 113.1,28.94 113.57,29.42 113.57,32.42 112.97,33.02 112.98,33.09 112.99,33.13 112.95,33.27 112.84,33.38 112.84,33.5 112.78,33.55 112.78,34.2 112.83,34.25 114.3,34.25
PP5000_PMIC on TOP (solid shape): 110.92,49.87 112.71,49.87 113.83,48.76 113.83,47.63 113.77,47.58 112.95,47.58 112.86,47.67 112.86,48.06 112.68,48.24 112.68,49.1 112.61,49.18 107.68,49.18 107.42,49.44 107.42,50.79 107.32,50.88 106.56,50.88 106.4,50.72 106.4,49.83 106.36,49.78 105.08,49.78 105.01,49.71 105.01,49.04 104.25,49.04 104.14,49 104.1,48.89 104.1,48.73 103.66,48.29 103.01,48.29 103.01,48.27 102.72,48.27 102.72,48.37 101.92,48.37 101.92,48.27 100.83,48.27 100.78,48.32 100.78,49.23 101.53,49.23 101.63,49.26 101.68,49.34 101.68,49.36 101.9,49.57 102.31,49.57 103.3,50.56 103.76,50.56 105.39,52.19 108.61,52.19
PP5000_PMIC on IN1 (solid shape): 114.31,45.59 114.36,45.55 115.15,44.76 115.18,44.68 115.13,44.6 114.96,44.51 114.89,44.33 114.98,44.13 115.17,44.05 115.18,44.05 115.28,44.06 115.36,44.11 115.47,44.12 115.53,44.03 115.53,43.9 115.5,43.89 115.32,43.74 115.25,43.52 115.28,43.36 115.37,43.23 115.39,43.16 115.37,43.09 115.28,42.96 115.25,42.81 115.32,42.58 115.5,42.43 115.53,42.42 115.53,41.86 115.5,41.84 115.35,41.59 115.5,41.35 115.53,41.33 115.53,36.75 114.54,35.76 113.71,35.76 113.71,36.43 113.71,36.47 113.7,36.5 113.68,36.53 113.66,36.56 113.58,36.64 113.58,36.84 113.58,36.87 113.57,36.91 113.55,36.94 113.53,36.97 113.45,37.05 113.6,37.19 113.64,37.19 113.74,37.21 113.82,37.27 114.23,37.68 114.29,37.75 114.31,37.84 114.32,37.87 114.39,37.94 114.44,38.02 114.46,38.12 114.46,40.37 114.44,40.46 114.39,40.55 114.13,40.81 114.13,42.33 114.11,42.42 114.05,42.51 113.9,42.66 113.9,43.81 113.95,43.89 113.96,43.99 113.94,44.11 113.85,44.21 113.82,44.28 113.84,44.36 113.88,44.4 113.91,44.43 113.93,44.46 113.94,44.5 113.94,44.53 113.94,45.59
PP5000_PMIC on IN1 (solid shape): outline of 704 points within 97.11,40.09 104.83,49.69
PP5000_PMIC on IN2 (solid shape): outline of 332 points within 104.15,33.44 115.35,51.56
PP5000_PMIC on IN3 (solid shape): 112.81,38.8 112.81,38.1 112.63,37.92 112.63,37.54 112.9,37.27 113.28,37.27 113.3,37.28 113.39,37.31 113.48,37.35 114.21,37.35 114.31,37.25 114.31,35.01 114.11,34.81 114.09,34.81 113.86,34.7 113.75,34.47 113.75,34.45 113.67,34.37 113.24,34.37 113.04,34.58 113.04,35.62 112.48,36.18 112.49,36.21 112.5,36.27 112.51,36.33 112.39,36.62 112.1,36.74 112.08,36.73 112.01,36.76 111.98,36.84 111.98,37.92 112.06,38.09 112.06,38.29 112.05,38.31 112.05,38.98 112.15,39.08 112.53,39.08
PP5000_USB_A0_VBUS on BOTTOM (solid shape): 140.65,43.77 140.65,43.34 140.88,43.11 142.02,43.11 143.01,42.12 143.01,42.09 145.34,39.76 148.65,39.76 149.82,38.6 149.82,34.91 149.71,34.8 140.95,34.8 140.75,35.01 140.75,35.1 149.22,35.1 149.22,35.31 148.42,35.31 148.42,35.1 140.75,35.1 140.75,35.6 149.22,35.6 149.22,35.8 148.42,35.8 148.42,35.6 140.75,35.6 140.75,36.1 149.22,36.1 149.22,36.31 148.42,36.31 148.42,36.1 140.75,36.1 140.75,36.59 149.23,36.59 149.23,36.82 148.4,36.82 148.4,36.59 140.75,36.59 140.75,37.09 149.22,37.09 149.22,37.31 148.41,37.31 148.41,37.09 140.75,37.09 140.75,38.61 140.34,39.02 139.2,39.02 139.16,39.06 139.16,41.06 138.97,41.25 138.97,42.88 138.79,43.06 137.32,43.06 137.24,43.14 137.24,43.85 137.3,43.9 140.52,43.9
PP5000_VCORE on TOP (solid shape): 103.29,43.97 103.59,43.97 103.83,43.73 103.83,41.72 103.83,41.6 103.89,41.49 104,41.39 104.48,41.39 104.55,41.31 104.55,41.19 104.5,41.14 103.87,41.14 103.31,41.69 103.31,41.97 103.13,42.15 103.13,42.75 102.78,43.11 102.42,43.47 102.42,44.07 102.54,44.19 103.07,44.19
PP5000_VCORE on IN2 (solid shape): 102.86,47.35 102.86,44.15 103.11,43.9 103.11,43.71 102.69,43.28 102.5,43.28 102.19,43.59 102.19,47.07 101.99,47.27 101.99,47.45 102.04,47.51 102.7,47.51
PP5000_VDRAM1 on TOP (solid shape): 107.91,43.98 107.91,43.14 107.78,43.02 107.35,43.45 106.87,43.45 106.53,43.78 106.53,44.28 106.66,44.41 107.48,44.41
PP5000_VDRAM1 on IN2 (solid shape): 107.1,45.2 107.15,45.16 107.15,43.92 107.02,43.8 106.71,43.8 106.61,43.9 106.61,44.25 106.28,44.58 106.28,45.14 106.34,45.2 107.1,45.2
PP5000_VDRAM1 on IN4 (solid shape): 106.29,48.48 106.27,48.44 106.24,48.36 106.23,48.27 106.25,48.17 106.29,48.07 106.25,47.97 106.23,47.87 106.33,47.61 106.59,47.51 106.64,47.51 107.2,46.95 107.2,44.31 107.02,44.13 106.15,44.13 105.8,44.49 105.8,46.32 105.64,46.47 105.64,47.03 105.63,47.11 105.59,47.17 104.48,48.28 104.48,48.7 104.73,48.96 104.74,48.96 104.81,49.03 105.73,49.03
PP5000_VGPU on IN2 (solid shape): 101.89,41.47 102,41.23 102.24,41.13 102.37,41.16 102.48,41.23 102.53,41.17 102.55,41.17 103.34,40.38 103.34,39.99 103.23,39.89 102.57,39.89 102.55,39.91 102.55,40.44 102.29,40.7 102.16,40.7 101.08,40.7 101.04,40.7 98.56,40.7 98.45,40.7 98.06,40.7 97.93,40.82 97.93,41.11 98.03,41.21 98.47,41.21 98.5,41.19 98.57,41.19 98.58,41.18 98.81,41.18 98.86,41.17 98.9,41.17 98.94,41.17 98.99,41.18 99.06,41.18 99.11,41.17 99.15,41.17 99.2,41.17 99.25,41.18 99.32,41.18 99.38,41.17 99.42,41.16 99.47,41.17 99.52,41.18 99.58,41.18 99.63,41.17 99.68,41.16 99.72,41.17 99.78,41.18 99.83,41.18 99.88,41.17 99.93,41.16 100.07,41.2 100.17,41.29 100.17,41.3 100.52,41.64 101.71,41.64
PP5000_VMODEM on TOP (solid shape): 104.17,47.69 105.42,47.69 105.65,47.46 105.65,44.75 106.35,44.05 106.35,43.38 106.31,43.34 106.2,43.34 106.2,43.34 105.7,43.34 105.57,43.47 105.57,43.7 105.14,44.13 105.14,44.39 103.25,46.28 103.25,46.91 102.98,47.18 102.98,48.01 103,48.03 103.83,48.03
PP5000_VMODEM on IN1 (solid shape): 105.83,44.12 105.83,43.44 105.82,43.41 105.39,42.98 105.39,42.67 106.03,42.03 106.03,41.18 106.23,40.98 106.23,40.8 106.13,40.7 106,40.7 105.88,40.82 105.88,40.9 105.49,41.28 105.49,41.84 105.14,42.2 105.11,42.23 105.07,42.27 104.83,42.5 104.83,43.49 105.29,43.95 105.29,44.13 105.34,44.18 105.77,44.18
PP5000_VPA on TOP (solid shape): 104.17,37.3 104.17,37.2 104.12,37.15 104,37.15 103.87,37.02 103.86,37 103.8,36.89 103.81,36.76 103.82,36.75 103.82,36.4 103.75,36.34 103.7,36.34 102.94,35.57 102.94,35.52 102.8,35.39 102.77,35.4 102.71,35.41 102.65,35.41 102.39,35.32 102.25,35.08 102.25,35.07 102.09,34.91 100.74,34.91 100.52,34.68 99.78,34.68 99.67,34.79 99.67,35.46 99.75,35.55 100.24,35.55 100.31,35.62 101.25,35.62 101.44,35.81 102.19,35.81 102.25,35.86 102.3,35.9 102.34,35.96 102.5,36.12 102.5,36.43 102.6,36.53 103.07,36.53 103.95,37.4 104.07,37.4
PP5000_VPROC11 on TOP (solid shape): 103.67,37.39 103.08,36.81 102.57,36.81 102.51,36.88 102.51,37.62 102.57,37.68 103.67,37.68
PP5000_VPROC11 on IN2 (solid shape): 103.28,37.96 103.28,37.51 103.39,37.41 103.39,37.28 103.38,37.27 103.38,37.16 103.26,37.04 102.52,37.04 102.47,37.09 102.47,37.76 102.37,37.86 102.36,37.86 102.29,37.89 102.21,37.91 101,37.91 100.97,37.9 100.57,37.5 98.6,37.5 98.34,37.25 98.34,37.06 98.26,36.98 98.12,36.98 97.72,37.37 97.72,37.83 97.92,38.04 98.23,38.04 98.27,38.08 98.32,38.11 100.58,38.11 100.79,38.32 102.93,38.32
PP5000_VPROC12 on IN2 (solid shape): 103.31,39.68 103.31,39.39 103.29,39.32 103.28,39.26 103.29,39.19 103.31,39.12 103.31,38.66 103.12,38.47 100.72,38.47 100.52,38.27 98.26,38.27 98.17,38.19 97.86,38.19 97.84,38.16 97.77,38.16 97.62,38.32 97.62,38.84 98.05,39.27 98.19,39.27 98.78,38.68 98.83,38.62 98.93,38.54 99.87,38.54 99.94,38.56 99.98,38.58 100.04,38.55 100.11,38.55 100.31,38.63 100.39,38.82 100.42,38.9 100.49,38.93 102.38,38.93 102.55,39.1 102.55,39.67 102.6,39.72 103.27,39.72
PP5000_VS1 on TOP (solid shape): 104.71,35.78 104.85,35.78 104.89,35.78 104.98,35.69 104.98,35.66 104.81,35.5 104.74,35.5 104.4,35.16 104.4,35.09 104.39,35.07 104.39,34.17 104.39,34.16 104.33,34.1 103.87,34.1 103.72,34.25 103.72,34.65 103.79,34.73 103.79,35.17 104.05,35.42 104.21,35.51 104.25,35.69 104.24,35.72 104.33,35.8 104.68,35.8
PP5000_VS1 on IN2 (solid shape): 103.91,34.93 104.25,34.93 104.34,34.84 104.34,34.13 104.22,34.02 103.38,34.02 103.26,34.15 103.26,34.84 103.38,34.97 103.87,34.97
PP5000_VS1 on IN4 (solid shape): 105.72,33.19 105.72,32.91 105.62,32.8 104.53,32.8 103.28,34.05 103.28,34.81 103.34,34.86 104.05,34.86
PP5000_VS2 on TOP (solid shape): 112.41,48.95 112.41,48.53 112.38,48.49 108.67,48.49 108.59,48.57 108.59,48.95 108.67,49.03 112.33,49.03
PP5000_VS2 on IN2 (solid shape): 109.23,48.83 109.23,47.08 108.87,46.72 108.47,46.72 108.34,46.85 108.34,48.62 108.59,48.88 109.18,48.88
PPVAR_BATT on BOTTOM (solid shape): 92.63,15.83 92.75,15.75 92.9,15.73 93.05,15.76 93.18,15.84 94.69,15.84 94.88,15.65 94.88,12.55 94.47,12.15 89.77,12.15 89.77,12.18 89.73,12.29 89.62,12.33 88.81,12.33 88.81,14.89 88.91,14.99 91.84,14.99 91.98,14.99 92.18,15.2 92.18,15.53 92.5,15.84 92.61,15.84
PPVAR_BUCKBOOST on TOP (solid shape): 129.43,38.84 129.43,37.12 128.82,36.51 128.82,35.58 128.63,35.4 128.19,35.4 127.58,34.78 127.55,34.79 127.49,34.8 127.43,34.8 127.14,34.69 127.02,34.4 127.02,34.34 127.04,34.28 127.05,34.25 126.94,34.14 126.32,34.14 126.3,34.12 126.14,33.96 126.06,33.96 126.01,34.01 126.01,35.35 126.07,35.44 126.17,35.43 126.28,35.38 126.4,35.36 126.81,35.77 126.4,36.18 126.28,36.16 126.17,36.11 126.07,36.1 126.01,36.19 126.01,36.35 126.02,36.35 126.02,37.01 126.04,37.04 126.04,37.95 126.35,38.26 127.36,38.26 128.08,38.97 129.29,38.97
PPVAR_PWR_IN on TOP (solid shape): 36.56,45.98 36.56,45.22 37.32,44.46 37.32,41.87 36.53,41.08 34.81,41.08 34.55,40.82 34.55,39.66 33.84,38.94 31.4,38.94 30.89,39.45 30.89,39.86 30.74,40.01 30.74,43.06 30.82,43.14 34.37,43.14 35.16,43.92 35.16,44.89 35.01,45.04 34.48,45.04 34.43,45.09 34.43,45.55 34.55,45.67 34.88,45.67 35.14,45.68 35.57,46.11 36.43,46.11
PPVAR_PWR_IN_BB on TOP (solid shape): 39.23,48.27 39.23,47.89 39.05,47.71 38.16,47.71 38.03,47.58 38.03,47.07 37.83,46.87 36.6,46.87 36.48,46.75 35.63,46.75 35.59,46.79 35.54,46.83 35.54,47.53 35.77,47.76 35.77,48.49 35.88,48.6 38.89,48.6
PPVAR_PWR_IN_BB on BOTTOM (solid shape): 124.77,40.04 127.31,40.04 127.31,36.18 126.96,36.18 126.75,36.38 125.38,36.38 124.98,35.97 124.98,35.16 124.62,34.8 117.41,34.8 116.95,35.26 116.95,40.09 117.08,40.21 124.6,40.21
PPVAR_PWR_IN_BB on IN5 (solid shape): outline of 1950 points within 35.67,36.96 125.33,63.51
PPVAR_SYS on TOP (solid shape): 134.68,34.85 134.68,32.26 133.46,31.04 133.1,31.04 132.85,31.3 132.85,31.65 133.92,32.72 133.92,34.3 133.61,34.6 133.1,34.6 133,34.7 133,35.21 133.26,35.46 134.07,35.46
PPVAR_SYS on TOP (solid shape): outline of 501 points within 79.03,15.27 105.19,22.43
PPVAR_SYS on BOTTOM (solid shape): outline of 571 points within 34.78,15.98 105.39,39.6
PPVAR_SYS_R on TOP (solid shape): 119.44,25.77 120.67,25.77 121.27,25.18 121.27,20.66 121.17,20.56 121.17,19.65 120.77,19.24 120.77,19.2 120.65,19.09 119.4,19.09 116.95,16.64 116.3,16.64 116.18,16.52 115.38,16.52 114.16,15.3 114.16,13.5 113.33,12.68 106.31,12.68 104.77,14.22 104.77,16.76 105.16,17.15 106.48,17.15 106.49,17.14 107.88,16.32 109.46,16.03 112.66,17.35 113.98,20.55 113.98,20.72 113.97,20.9 115.5,22.43 118.78,22.43 118.78,25.46 118.88,25.56 118.91,25.56 119.16,25.81 119.4,25.81
PPVAR_SYS_R on BOTTOM (solid shape): outline of 192 points within 102.45,11.82 128.41,26.42
PPVAR_USB_C0_VBUS on TOP (solid shape): outline of 200 points within 21.83,37.45 32.09,47.91
PPVAR_USB_C0_VBUS on BOTTOM (solid shape): 28.91,47.81 28.91,47.78 28.94,47.76 28.94,44.89 28.91,44.86 28.91,42.53 28.51,42.12 28.51,40.85 28.43,40.77 27.08,40.77 26.91,40.95 26.92,41.03 26.92,42.11 27.02,42.21 27.02,42.23 27.03,42.24 27.06,42.32 27.07,42.41 27.07,44.34 27.21,44.49 27.26,44.68 27.25,44.8 27.2,44.91 27.19,44.92 27.19,45.04 27.2,45.06 27.22,45.1 27.23,45.15 27.23,45.23 27.25,45.29 27.26,45.35 27.25,45.4 27.23,45.46 27.23,45.54 27.19,45.64 27.08,45.69 27.05,45.69 27.03,45.71 23.76,45.71 23.15,46.32 23.15,48.01 23.53,48.39 28.33,48.39
PPVAR_USB_C0_VBUS on IN3 (solid shape): outline of 668 points within 22.82,40.72 33.38,48.87
PPVAR_USB_C0_VBUS_R on TOP (solid shape): 30.08,40.75 30.08,40.19 30.39,39.88 30.59,39.88 30.72,39.76 30.72,39.38 31.35,38.74 32.88,38.74 33.08,38.54 33.08,37.29 32.88,37.09 30.72,37.09 30.34,37.47 28.96,37.47 28.86,37.57 28.86,40.8 29.14,41.08 29.75,41.08
PPVAR_VSYS_R on BOTTOM (solid shape): 101.88,15.27 101.88,11.99 101.84,11.94 99.17,11.94 99.02,12.1 99.02,12.91 98.74,13.19 98.28,13.19 97.8,13.67 95.36,13.67 95.11,13.93 95.11,15.32 95.23,15.45 101.71,15.45
SPK_L_N on TOP (solid shape): 23.81,10.9 23.81,9.15 24.04,8.92 24.92,8.92 25.21,8.64 25.21,8.24 25.18,8.21 24.6,8.21 24.02,7.63 23.46,7.63 23.05,8.04 23.05,10.9 23.12,10.98 23.73,10.98
SPK_L_N on BOTTOM (solid shape): 26.93,11.28 26.93,8.47 26.77,8.31 26.77,7.7 26.54,7.46 23.51,7.46 23.27,7.7 23.27,8.39 23.81,8.92 25.64,8.92 25.94,9.23 25.94,11.21 26.09,11.36 26.86,11.36
SPK_L_P on TOP (solid shape): 23.05,7.71 23.05,6.23 22.92,6.1 21.02,6.1 20.86,6.27 20.86,8.46 20.97,8.57 22.2,8.57
SPK_L_P on BOTTOM (solid shape): 25.64,11.28 25.64,9.45 25.63,9.45 25.63,9.26 25.63,9.22 25.54,9.12 23.63,9.12 23.02,8.52 23.02,7.65 22.72,7.35 21.62,7.35 21.37,7.6 21.37,9.54 23.19,11.36 25.56,11.36
SPK_R_N on TOP (solid shape): 28.76,10.98 28.76,10.06 28.84,9.99 28.84,9.23 28.99,9.07 29.52,9.07 29.58,9.02 29.58,7.53 29.52,7.47 28.38,7.47 28.15,7.7 28.15,10.98 28.23,11.06 28.68,11.06
SPK_R_N on BOTTOM (solid shape): 29.75,11.21 29.75,8.16 29.22,7.63 28.53,7.63 28.38,7.78 28.38,8.24 28.53,8.39 28.53,11.28 28.61,11.36 29.6,11.36
SPK_R_P on TOP (solid shape): 27.92,10.9 27.92,8.41 27.92,8.41 27.92,8.21 27.6,7.89 27.11,7.89 26.98,8.01 26.98,8.25 26.38,8.25 26.25,8.39 26.25,10.98 26.32,11.06 27.77,11.06
SPK_R_P on BOTTOM (solid shape): 28.38,11.28 28.38,8.46 28.23,8.31 28.23,7.78 28.08,7.63 27.2,7.63 26.97,7.86 26.97,8.21 27.24,8.48 27.24,11.28 27.31,11.36 28.3,11.36
TS3A227E_POWER on TOP (solid shape): 11.08,24.8 11.08,24.54 11.21,24.41 11.21,24.34 11.26,24.24 11.36,24.19 11.43,24.19 11.62,24.01 12.15,24.01 12.17,23.99 13.03,23.99 13.24,23.79 13.67,23.79 13.86,23.59 13.86,23.12 13.76,23.02 12.91,23.02 12.56,23.37 11.39,23.37 11.34,23.42 11.34,23.63 10.83,24.14 10.83,24.77 10.88,24.82 11.06,24.82
TX_AVCC on TOP (solid shape): 22.09,20.53 22.09,19.84 22.06,19.81 22.06,18.85 21.93,18.71 21.13,18.71 21.06,18.78 21.06,20.46 21.19,20.58 22.03,20.58
TX_AVCC on IN2 (solid shape): 23.35,25 23.35,20.42 23.33,20.35 23.26,20.32 23.17,20.33 23.01,20.29 22.88,20.18 22.75,20.18 22.72,20.21 22.63,20.28 22.51,20.3 22.49,20.3 22.29,20.22 22.21,20.02 22.21,19.99 22.11,19.9 21.2,19.9 21.1,20 21.1,20.76 21.3,20.97 22.03,20.97 22.12,21.06 22.23,21.2 22.26,21.39 22.25,21.43 22.36,21.55 22.36,22.79 22.36,23.1 22.36,23.75 22.29,23.83 22.29,25.31 22.36,25.38 22.97,25.38
TX_OVDD on TOP (solid shape): 29.88,36.2 29.88,35.41 29.75,35.29 28.81,35.29 28.63,35.46 28.25,35.46 28.15,35.57 28.15,36.28 28.18,36.31 29.77,36.31
TX_OVDD on TOP (solid shape): 27.13,16.06 27.26,15.93 27.44,15.93 27.58,15.79 27.58,14.96 27.52,14.9 27.14,14.9 27.11,14.93 27.11,15.58 26.93,15.76 26.93,17.12 27.13,17.12
TX_OVDD on TOP (solid shape): 33.79,29.11 33.79,28.25 34.1,27.95 34.4,27.95 35.7,26.65 35.7,24.42 35.57,24.29 34.77,24.29 34.31,23.82 34.03,23.82 34.03,23.82 33.04,23.82 33.04,24.01 33.05,24.02 34.1,24.02 34.63,24.55 34.63,26.07 33.18,27.51 31.43,27.51 31.28,27.67 31.28,28.05 31.35,28.12 32.27,28.12 32.42,28.28 32.42,29.11 32.49,29.19 33.71,29.19
TX_OVDD on TOP (solid shape): 23.87,17.09 23.87,14.93 21,12.05 20.31,12.05 20.2,12.17 20.2,12.64 20,12.84 19.35,12.84 19.29,12.9 17.28,12.9 16.58,13.61 16.41,13.61 16.13,13.88 15.96,13.88 15.81,14.04 15.81,14.89 15.91,14.99 16.71,14.99 17.39,14.31 18.51,14.31 18.81,14.01 20.81,14.01 21.96,15.16 22.42,15.16 23,15.74 23,17.03 23.1,17.13 23.83,17.13
TX_OVDD on BOTTOM (solid shape): 32.95,28.2 32.95,27.06 32.83,26.93 30.77,26.93 30.72,26.98 30.72,27.39 30.88,27.55 30.88,28.07 31.22,28.41 32.74,28.41
TX_OVDD on IN1 (solid shape): outline of 760 points within 23.06,15.63 33.89,36.72
TX_OVDD on IN2 (solid shape): 25.74,28.78 25.74,28.77 25.82,28.61 25.98,28.53 26,28.53 27.39,27.13 28.31,27.13 28.44,26.98 28.63,26.93 28.82,26.98 28.95,27.13 30.73,27.13 31.7,28.1 32.08,28.1 32.2,27.98 32.2,27.37 31.32,26.49 27.08,26.49 25.38,28.18 25.38,28.2 25.28,28.44 25.04,28.55 25.02,28.55 24.11,29.45 24.13,29.49 24.16,29.55 24.17,29.62 24.16,29.66 24.15,29.73 24.27,29.85 24.68,29.85
TX_OVDD on IN3 (solid shape): outline of 275 points within 34.63,17.2 38.62,25.13
VA12_PMU on TOP (solid shape): 112.7,45.25 112.7,44.2 112.43,43.92 110.63,43.92 110.57,43.86 110.57,42.52 109.89,41.85 109.74,41.85 109.73,41.85 109.62,41.88 109.52,41.85 109.51,41.85 109.26,41.85 109.15,41.96 109.15,42.13 109.59,42.57 109.97,42.57 110.08,42.67 110.08,42.68 110.17,42.77 110.17,44 110.42,44.25 111.67,44.25 111.77,44.35 111.77,44.47 111.79,44.5 111.79,44.73 111.77,44.76 111.77,45.22 111.8,45.25 112.7,45.25
VA12_PMU on BOTTOM (solid shape): 106.26,50.02 111.34,50.02 113.35,48.01 113.35,45.64 113.19,45.48 112.19,45.48 112.12,45.55 112.12,47.28 112.1,47.42 112.02,47.53 110.95,48.6 110.84,48.68 110.7,48.71 105.73,48.71 105.37,49.06 105.26,49.14 105.12,49.16 96.89,49.16 96.75,49.14 96.63,49.06 95.44,47.86 95.36,47.75 95.33,47.61 95.33,47.35 95.23,47.25 93.71,47.25 93.56,47.1 93.56,44.42 90.21,41.08 89.42,41.08 89.37,41.13 89.37,42.2 89.42,42.25 90.05,42.25 90.12,42.32 90.12,42.96 92.26,45.1 92.26,45.12 92.31,45.17 92.31,47.83 93.02,48.55 94.37,48.55 96.21,50.39 105.89,50.39
VA12_PMU on IN1 (solid shape): 112.84,46.06 112.84,44.84 112.48,44.48 112.4,44.48 111.82,45.07 111.82,46.06 111.95,46.18 112.71,46.18
VA12_PMU on IN1 (solid shape): 80.46,37.79 80.46,37.07 80.57,36.96 81.51,36.96 81.58,36.88 81.58,36.86 81.42,36.7 80.33,36.7 80.33,36.71 80.26,36.71 80,36.97 80,37.84 80.02,37.85 80.39,37.85
VA12_PMU on IN2 (solid shape): 113.22,45.7 113.22,45.32 113.11,45.22 112.02,45.22 111.87,45.37 111.87,45.94 111.95,46.03 111.99,46.15 112.02,46.18 112.73,46.18
VA12_PMU on IN4 (solid shape): 113.11,45.88 113.11,45.24 113.09,45.22 112.07,45.22 111.94,45.36 111.92,45.38 111.92,45.81 112,45.92 112.02,46.06 112.15,46.18 112.81,46.18
VA12_PMU on IN4 (solid shape): outline of 530 points within 80.11,30.44 92.85,37.81
VA12_PMU on IN5 (solid shape): outline of 292 points within 92.01,33.48 100.24,48.19
VCAMD_PMU on TOP (solid shape): 110.83,44.81 110.83,44.48 110.78,44.43 109.91,44.43 109.43,43.95 109.43,42.57 109.17,42.3 109.05,42.3 109.05,44.21 109.53,44.69 109.53,44.69 109.75,44.91 110.73,44.91
VCORE on TOP (solid shape): 102.27,45.03 102.27,43.4 103,42.66 103,42.1 103.21,41.9 103.21,41.69 103.91,40.98 104.45,40.98 104.55,40.88 104.55,40.81 104.48,40.73 103.67,40.73 102.75,41.64 102.47,41.64 101.01,43.11 101.01,45.1 101.05,45.14 102.16,45.14
VDRAM1 on IN1 (solid shape): 107.5,45.56 107.5,44.86 107.69,44.67 107.69,42.4 107.61,42.32 107.61,41.31 107.41,41.1 107.15,41.1 107.09,41.15 107.09,41.38 107.15,41.43 107.15,42.45 107.22,42.53 107.22,43.89 107.25,44 107.22,44.11 107.22,44.14 107.24,44.19 107.25,44.25 107.24,44.31 107.22,44.37 107.22,44.38 107.13,44.48 107.03,44.52 106.87,44.69 106.87,45.53 106.94,45.61 107.45,45.61
VGPU on TOP (solid shape): 102.34,41.49 102.79,41.49 103.79,40.49 103.79,40.34 103.94,40.19 104.48,40.19 104.55,40.12 104.55,40 104.47,39.92 103.81,39.92 103.39,40.34 103.39,40.44 103.09,40.73 103.09,40.74 103.04,40.82 102.97,40.87 102.95,40.88 102.84,40.88 102.79,40.93 101.38,40.93 101.25,40.81 100.39,40.81 100.29,40.9 100.29,42.61 100.36,42.67 101.17,42.67
VIO18_MT6358 on BOTTOM (solid shape): 102.79,30.57 102.83,30.57 103.13,30.57 103.17,30.57 104.28,30.57 104.45,30.39 104.45,29.68 104,29.22 102.75,29.22 102.45,28.92 101.63,28.92 101.61,28.94 101.61,30.39 101.78,30.57 102.01,30.57 102.05,30.57 102.48,30.57
VIO18_MT6358 on IN3 (solid shape): outline of 328 points within 103.79,30.09 106.85,37.04
VIO18_PMU_AP on TOP (solid shape): 85.53,29.9 85.53,27.08 85.52,27.06 85.4,26.95 84.83,26.95 84.82,26.96 84.59,26.96 84.5,27.05 84.5,27.71 84.62,27.82 84.62,28.18 84.56,28.24 84.56,29.17 84.49,29.24 84.49,29.39 84.49,29.39 84.49,29.83 84.51,29.86 85,29.86 85.07,29.93 85.5,29.93
VIO18_PMU_AP on TOP (solid shape): 88.78,32.8 88.78,32.65 88.97,32.46 88.97,32.3 89.09,32.19 89.09,31.68 89.09,31.68 89.09,31.55 89.09,30.62 89.45,30.26 89.45,29.92 90,29.37 90.19,29.37 90.25,29.32 90.25,29.16 90.21,29.12 89.27,29.12 89.19,29.05 88.47,29.05 88.43,29.09 88.43,31.45 88.73,31.76 88.73,32.23 88.53,32.44 88.53,32.8 88.6,32.88 88.7,32.88
VIO18_PMU_AP on IN2 (solid shape): 84.86,30.39 84.86,28.38 84.79,28.3 84.59,28.3 84.56,28.33 84.56,28.86 84.33,29.1 84.33,30.47 84.38,30.52 84.74,30.52
VIO18_PMU_AP on IN3 (solid shape): outline of 240 points within 90.38,30.08 95.42,36.33
VIO18_PMU_AP on IN4 (solid shape): outline of 164 points within 94.5,40.01 98.76,47.08
VIO18_PMU_AP on IN4 (solid shape): outline of 612 points within 77.48,26.35 93.89,36.46
VIO18_PMU_AP on IN5 (solid shape): outline of 667 points within 78.21,35.64 99.8,51.82
VPROC11 on TOP (solid shape): 101.53,37.93 101.53,36.16 101.16,35.79 100.4,35.79 100.34,35.85 100.34,38 100.41,38.08 101.38,38.08
VS1 on TOP (solid shape): 104.53,36.11 104.53,35.98 104.45,35.9 104,35.9 103.96,35.87 103.95,35.87 103.84,35.78 103.8,35.64 103.64,35.49 103.64,34.83 103.49,34.68 103.49,33.23 103.31,33.05 100.97,33.05 100.64,33.38 100.64,34.52 100.87,34.74 102.34,34.74 102.48,34.64 102.65,34.6 102.92,34.7 103.05,34.95 103.09,34.99 103.09,35.51 103.77,36.18 104.45,36.18
VS1_LDO1 on TOP (solid shape): 104.46,32.19 104.63,32.19 104.68,32.14 104.68,31.97 103.61,30.9 103.61,30.6 103.25,30.24 101.94,30.24 101.9,30.2 101.9,29.91 101.81,29.83 101.66,29.83 101.25,30.24 101,30.24 100.26,30.98 99.8,30.98 99.72,31.06 99.72,31.43 99.75,31.47 100.54,31.47 100.89,31.12 102.97,31.12 103.72,31.86 103.72,32.12 103.79,32.19 104.45,32.19
VS1_LDO1 on IN1 (solid shape): 104.92,32.66 104.92,32.1 104.5,31.69 103.84,31.69 103.72,31.81 103.72,32.09 103.79,32.17 104.25,32.17 104.45,32.37 104.45,32.65 104.5,32.7 104.87,32.7
VS1_PMU on TOP (solid shape): 103.34,32.58 103.34,31.7 102.92,31.28 100.95,31.28 100.42,31.81 99.65,31.81 99.6,31.86 99.6,32.24 99.74,32.38 100.59,32.38 100.89,32.68 103.23,32.68
VS2 on TOP (solid shape): 111.2,46.42 111.2,45.24 111.02,45.07 109.6,45.07 108.99,44.45 108.99,43.18 108.9,43.09 108.82,43.09 108.75,43.17 108.75,45.35 108.76,45.37 108.76,45.82 108.77,45.83 108.77,46.31 109,46.54 111.08,46.54
VS2_PMU on TOP (solid shape): 112.56,48.14 112.56,47.73 112.4,47.58 111.8,47.58 111.8,47.39 111.18,46.77 108.81,46.77 108.65,46.92 108.65,48.07 108.8,48.22 112.48,48.22
VS2_PMU_R on TOP (solid shape): 112.72,47.14 112.72,45.41 111.37,45.41 111.36,45.42 111.36,46.69 111.91,47.24 112.62,47.24
VS2_PMU_R on IN1 (solid shape): 111.67,46.13 111.67,45.35 111.49,45.17 110.6,45.17 109.61,44.18 109.61,42.42 108.95,41.77 108.95,41.11 109.05,41.02 109.05,40.97 109.04,40.96 109.06,40.72 109.28,40.65 109.34,40.63 109.35,40.58 109.32,40.47 109.33,40.36 109.34,40.33 109.28,40.28 109.18,40.28 109.12,40.25 109.11,40.25 108.99,40.25 108.99,40.31 109,40.33 108.97,40.6 108.69,40.61 108.62,40.59 108.56,40.61 108.48,40.65 108.36,40.66 108.31,40.7 108.31,40.82 108.32,40.82 108.67,41.17 108.67,41.91 109.16,42.4 109.16,43.5 109,43.67 109,44.56 110.62,46.18 111.62,46.18
VSIM2_PMU on TOP (solid shape): 20,11.26 20,10.67 19.36,10.04 17.33,10.04 17.25,10.12 17.25,11.26 17.33,11.33 19.92,11.33
VSIM2_PMU on IN1 (solid shape): 110.44,38.73 110.57,38.73 110.58,38.72 110.93,38.72 111.31,38.34 113.52,38.34 113.74,38.12 113.74,37.93 113.51,37.7 113.27,37.7 112.99,37.98 110.78,37.98 110.03,38.74 109.99,38.87 109.88,38.95 109.87,38.95 109.74,39.08 109.31,39.08 109.16,39.23 109.16,39.31 109.86,39.31
N39948003 on TOP (solid shape): 129.3,32.99 129.3,32.61 129.3,32.59 128.88,32.59 127.97,31.68 127.09,31.68 127.09,31.69 126.3,31.69 126.29,31.7 126.29,31.87 126.31,31.89 127.7,31.89 128.81,33 129.3,33
N39948199 on TOP (solid shape): 125.4,30.77 125.4,29.66 125.53,29.53 125.53,29.19 126.32,28.4 126.32,27.61 126.29,27.57 125.77,27.57 125.71,27.51 124.81,27.51 124.54,27.79 124.54,28.32 125.09,28.88 125.09,29.72 125.19,29.83 125.19,30 125.2,30 125.2,30.75 125.22,30.78 125.32,30.78 125.33,30.79 125.38,30.79
N39948619 on BOTTOM (solid shape): 132.04,24.03 132.04,23.27 131.68,22.92 130.87,22.92 130.72,23.07 130.67,23.07 130.67,24.14 130.82,24.29 131.78,24.29
N39948871 on TOP (solid shape): 125.78,29.98 125.84,29.92 125.84,29.84 126.42,29.84 127.4,28.86 127.82,28.86 127.95,28.73 127.95,28.17 127.82,28.05 127.11,28.05 125.73,29.43 125.73,29.61 125.6,29.74 125.6,30.76 125.62,30.78 125.78,30.78
N39949154 on TOP (solid shape): 129.6,31.81 129.6,30.97 129.45,30.82 129.45,30.6 129.42,30.56 129.4,30.5 129.4,30.11 128.89,30.11 127.69,31.3 126.32,31.3 126.31,31.31 126.31,31.49 127.09,31.49 127.09,31.5 128.05,31.5 128.06,31.49 128.76,32.19 129.22,32.19
N39971047 on TOP (solid shape): 129.43,34.26 129.43,33.54 129.08,33.19 128.69,33.19 127.61,32.11 126.33,32.11 126.31,32.13 126.31,32.29 127.31,32.29 127.49,32.47 127.6,32.47 128.17,33.05 128.17,33.15 128.38,33.36 128.38,34.14 128.58,34.35 129.35,34.35
N39984522 on TOP (solid shape): 124.59,29.56 124.58,29.56 124.58,29.33 124.37,29.11 124.32,29.12 124.03,29 123.91,28.71 123.96,28.51 124.11,28.36 124.19,28.28 124.19,27.84 124.14,27.79 123.13,27.79 123.1,27.81 123.1,28.44 124.4,29.74 124.4,30.75 124.43,30.78 124.59,30.78
N46324535 on TOP (solid shape): 106.05,42.15 106.05,41.82 106.15,41.72 106.15,41.21 106.08,41.14 105.88,41.14 105.72,41.29 105.72,41.64 105.32,42.05 105.32,42.28 105.52,42.48 105.72,42.48
N51761964 on TOP (solid shape): 103,46.88 103,45.42 102.89,45.31 101.13,45.31 100.97,45.46 100.97,46.95 101.07,47.05 102.83,47.05
N51761964 on TOP (solid shape): 96.3,31.6 96.3,29.29 96.17,29.17 95.77,29.17 95.77,29.17 95.74,29.15 94.47,29.15 94.19,29.43 94.19,30.23 94.36,30.39 94.68,30.39 94.85,30.56 94.85,30.6 94.88,30.71 94.85,30.83 94.85,31.29 94.88,31.4 94.85,31.51 94.85,31.64 94.88,31.67 96.24,31.67
N51761964 on BOTTOM (solid shape): 87.94,35.97 87.94,35.21 87.79,35.06 86.72,35.06 86.6,35.19 86.6,36.02 86.65,36.07 87.84,36.07
N51761964 on BOTTOM (solid shape): 94.73,32.6 95.09,32.6 95.17,32.52 95.17,32.17 95.16,32.13 95.16,32.08 95.05,31.97 91.11,31.97 91,32.08 91,32.42 91.05,32.47 91.05,32.54 91.13,32.62 94.71,32.62
N51761964 on IN2 (solid shape): 101.96,46.85 101.96,45.38 101.79,45.2 100.2,45.2 100.05,45.35 100.05,46.18 100.93,47.06 101.76,47.06
N51761964 on IN2 (solid shape): 95.02,30.27 95.02,29.56 94.92,29.47 94.92,29.37 94.67,29.11 94.67,28.81 94.62,28.76 94.29,28.76 94.17,28.89 94.17,29.16 94.2,29.19 94.2,30.24 94.32,30.36 94.93,30.36
N51761964 on IN3 (solid shape): outline of 414 points within 86.08,28.58 94.94,36.21
N51761964 on IN4 (solid shape): 101.71,46.95 101.71,44.64 101.48,44.41 101.07,44.41 100.82,44.66 100.6,44.66 100.1,45.16 100.1,45.46 99.83,45.73 99.83,46.44 100.45,47.07 101.6,47.07
N51761964 on IN4 (solid shape): 86.9,36.15 86.94,36.15 86.97,36.15 87.34,36.15 87.76,35.73 88.07,35.73 88.4,35.4 88.4,35.12 88.22,34.95 88.02,34.95 87.93,35 87.83,35.02 87.78,35.01 87.74,35 87.72,35.02 86.76,35.02 86.72,34.99 86.47,34.99 86.11,35.34 86.11,35.75 86.51,36.15
N51761964 on IN4 (solid shape): 93.81,30.71 94.06,30.71 94.13,30.69 94.19,30.69 94.26,30.69 94.33,30.71 94.46,30.71 94.53,30.69 94.6,30.69 94.66,30.69 94.73,30.71 94.9,30.71 95.13,30.49 95.13,29.9 95.1,29.82 95.08,29.72 95.1,29.63 95.13,29.55 95.13,29.32 94.57,28.76 94.12,28.76 93.28,29.59 93.28,29.78 93.24,29.82 93.24,30.54 93.42,30.71 93.76,30.71
N51761964 on IN5 (solid shape): outline of 960 points within 85.91,30.23 103.41,49.59
N52164418 on TOP (solid shape): 107.48,32.65 107.96,32.16 107.96,31.71 107.86,31.61 107.35,31.61 107.15,31.81 107.15,33.11 107.27,33.24 107.48,33.24
N54517064 on TOP (solid shape): 31.58,10.29 31.58,6.56 31.28,6.25 26.83,6.25 26.17,6.92 26.17,7.82 26.27,7.91 26.76,7.91 27.54,7.13 30.25,7.13 30.74,7.63 30.74,9.91 31.2,10.37 31.5,10.37
N54517066 on TOP (solid shape): 31.58,10.75 31.58,10.6 31.5,10.52 31.12,10.52 30.59,9.99 30.59,7.7 30.29,7.4 29.9,7.4 29.87,7.44 29.87,7.99 29.75,8.11 29.75,10.52 30.06,10.83 31.5,10.83
N54517443 on TOP (solid shape): 24.37,7.09 24.37,5.76 24.27,5.66 24.14,5.66 24.08,5.72 23.46,5.72 23.39,5.79 23.39,7.05 23.53,7.18 24.28,7.18
N54517445 on TOP (solid shape): 25.29,7.71 25.29,6.37 24.79,5.87 24.79,5.74 24.7,5.66 24.56,5.66 24.52,5.7 24.52,7.79 24.59,7.86 25.14,7.86
N54601609 on TOP (solid shape): 32.6,31.98 32.59,31.92 32.59,31.89 32.61,31.8 32.65,31.72 32.65,31.25 33.47,30.43 33.47,29.86 33.41,29.8 32.95,29.8 32.68,30.07 32.57,30.18 32.04,30.18 31.71,29.85 31.35,29.85 31.27,29.93 31.27,31.24 32.11,32.09 32.49,32.09
N55506085 on BOTTOM (solid shape): 140.57,38.49 140.57,35.57 140.44,35.44 139.56,35.44 139.43,35.57 139.43,36.71 139.05,37.09 139.05,38.61 139.17,38.74 140.32,38.74
N57879546 on TOP (solid shape): 32.57,32.62 32.57,32.24 32.05,32.24 31.82,32.01 30.44,32.01 30.36,32.09 30.36,33.31 30.42,33.36 31.83,33.36
N57881020 on TOP (solid shape): 33.34,34.07 33.34,33.72 33.38,33.62 33.49,33.57 33.49,32.31 33.33,32.16 32.92,32.16 32.8,32.16 32.72,32.24 32.72,32.68 32.72,32.68 32.72,33.99 32.88,34.14 33.27,34.14
N58463847 on TOP (solid shape): 48.1,12.4 48.62,12.4 48.73,12.3 48.73,11.97 48.42,11.66 46.59,11.66 46.06,11.13 44.76,11.13 44.69,11.21 44.69,12.58 44.92,12.81 47.69,12.81
N58463851 on TOP (solid shape): 42.78,12.58 43.54,12.58 43.77,12.35 43.77,11.21 43.7,11.13 42.07,11.13 41.87,11.33 41.87,12.81 41.94,12.88 42.48,12.88
N58463944 on TOP (solid shape): 41.61,12.68 41.61,11.39 41.54,11.31 40.95,11.31 40.45,10.8 39.35,10.8 39.23,10.93 39.23,11.61 39.63,12.02 40.72,12.02 40.85,12.15 40.85,12.71 41,12.86 41.44,12.86
N60472929 on TOP (solid shape): 60.65,9.66 61.32,9.66 61.45,9.79 61.45,9.91 61.58,10.04 61.83,10.04 61.96,9.91 61.96,9.28 61.83,9.15 60.43,9.15 60.18,9.41 60.15,9.45 60.1,9.48 59.67,9.91 59.39,9.91 59.36,9.94 59.25,10.02 59.12,10.04 57.67,10.04 57.54,10.02 57.43,9.94 57.4,9.91 56.62,9.91 56.37,9.66 56.37,9.02 56.5,8.9 56.75,8.9 56.75,8.39 56.55,8.18 56.24,8.18 56.1,8.04 55.67,8.04 55.6,8.12 55.6,8.42 55.87,8.7 55.93,8.8 55.96,8.92 55.96,9.9 56.43,10.38 59.93,10.38
N60574427 on TOP (solid shape): 61.15,15.3 61.53,15.3 61.62,15.21 61.62,14.88 62.47,14.03 62.47,13.29 62.34,13.16 61.6,13.16 61.4,13.37 61.4,14.17 60.93,14.64 60.89,14.64 60.84,14.69 60.84,14.87 60.82,14.89 60.28,14.89 60.23,14.94 60.23,15.37 60.31,15.46 60.99,15.46
N60574429 on TOP (solid shape): 63.02,14.56 63.02,13.26 62.95,13.19 62.75,13.19 62.7,13.24 62.7,14.08 61.81,14.97 61.81,15.14 61.87,15.2 62.38,15.2
N60701330 on TOP (solid shape): 39.81,38.94 39.81,38.24 39.72,38.15 39.29,38.15 39.22,38.13 39.16,38.08 37.4,38.08 37.3,38.18 37.3,38.94 37.37,39.02 39.73,39.02
