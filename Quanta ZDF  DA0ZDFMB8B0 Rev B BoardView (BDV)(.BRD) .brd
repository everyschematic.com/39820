# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
DVDD_CORE on IN4 (solid shape): 85.18,40.61 85.18,39.11 85.05,38.99 84.87,38.99 84.45,39.41 84.45,39.68 84.54,39.77 84.54,40.13 84.3,40.37 84.3,40.7 84.4,40.79 85,40.79
DVDD_CORE on IN4 (solid shape): 86.7,40.16 86.7,38.92 86.49,38.7 86.49,38.6 86.24,38.36 86.17,38.36 86.11,38.42 86.11,39.39 85.87,39.64 85.87,39.94 86.02,40.09 86.32,40.09 86.43,40.2 86.66,40.2
DVDD_CORE on IN5 (solid shape): outline of 308 points within 83.88,36.02 91.35,40.82
DVDD_GPU on TOP (solid shape): 88.45,40.83 88.45,39.64 87.89,39.08 87.79,39.08 87.69,39.18 87.69,40.78 87.84,40.93 88.35,40.93
DVDD_GPU on TOP (solid shape): 100.14,42.43 100.14,40.94 99.98,40.78 99.98,40.77 98.69,40.77 98.53,40.93 98.53,42.61 98.61,42.69 99.88,42.69
DVDD_GPU on BOTTOM (solid shape): 89.11,41.43 89.11,40.85 88.98,40.72 88.81,40.72 88.58,40.49 88.58,40.06 88.81,40.06 88.81,39.27 88.54,39 88.24,39 87.97,38.72 87.82,38.72 87.75,38.79 87.75,39.19 87.74,39.2 87.74,41.19 87.84,41.29 88.22,41.29 88.47,41.54 89.01,41.54
DVDD_GPU on IN1 (solid shape): 88.27,40.91 88.45,40.91 88.78,40.58 88.78,39.99 88.38,39.6 88.38,38.06 88.2,37.87 87.78,37.87 87.71,37.95 87.71,40.8 87.82,40.91 88.27,40.91
DVDD_GPU on IN2 (solid shape): 99.57,42.87 100.06,42.87 100.27,42.65 100.27,41.63 99.98,41.33 98.64,41.33 98.64,41.34 98.56,41.34 98.4,41.5 98.4,42.71 98.64,42.95 99.48,42.95
DVDD_GPU on IN2 (solid shape): 88.72,40.91 88.72,40.62 88.78,40.57 88.78,39.56 88.65,39.43 88.59,39.43 88.44,39.29 88.44,39.12 88.35,39.03 88.35,38.7 87.89,38.24 87.74,38.24 87.71,38.27 87.71,38.52 87.66,38.57 87.66,40.73 87.82,40.88 87.84,40.88 88.09,41.14 88.5,41.14
DVDD_GPU on IN3 (solid shape): outline of 162 points within 87.64,38.49 96.12,46.11
DVDD_GPU on IN4 (solid shape): 99.58,43.08 99.58,42.29 99.36,42.07 98.77,42.07 98.2,42.64 97.71,42.64 97.54,42.81 97.54,43.4 97.8,43.65 99.01,43.65
DVDD_GPU on IN4 (solid shape): outline of 474 points within 87.75,38.59 96.02,51.27
DVDD_GPU on IN5 (solid shape): 97.21,46.31 97.22,46.3 97.25,46.29 97.26,46.28 99.14,46.28 99.35,46.08 99.35,42.58 99.27,42.5 97.8,42.5 96.4,43.9 96.76,43.9 96.76,43.86 96.77,43.81 96.79,43.77 96.82,43.73 96.85,43.7 96.89,43.67 96.93,43.65 96.98,43.63 97.02,43.63 97.07,43.63 97.12,43.64 97.16,43.66 97.2,43.68 97.24,43.71 97.27,43.75 97.29,43.79 97.31,43.83 97.31,43.88 97.31,43.93 97.31,43.97 97.29,44.02 97.27,44.06 97.24,44.1 97.2,44.13 97.16,44.15 97.12,44.17 97.07,44.18 97.02,44.18 96.98,44.18 96.93,44.16 96.89,44.14 96.85,44.11 96.82,44.08 96.79,44.04 96.77,44 96.76,43.95 96.76,43.9 96.4,43.9 95.06,45.25 95.06,47.47 95.14,47.55 95.96,47.55
DVDD_PROC_B on TOP (solid shape): 100.16,38.03 100.16,35.89 100.16,35.8 100.09,35.73 98.76,35.73 98.57,35.92 98.57,37.9 98.74,38.07 100.12,38.07
DVDD_PROC_B on TOP (solid shape): 82.06,32.1 82.97,32.1 82.97,32.34 83.83,32.34 83.94,32.23 83.94,30.71 83.78,30.55 81.68,30.55 81.47,30.33 80.4,30.33 80.27,30.46 80.27,31.12 81.49,32.34 82.06,32.34
DVDD_PROC_B on BOTTOM (solid shape): 83.34,36.52 83.34,36.27 83.48,36.13 83.57,36.11 83.61,36.11 83.65,36.11 83.7,36.12 83.8,36.12 83.82,36.14 83.86,36.14 83.92,36.21 84.17,36.21 84.18,36.21 84.56,36.21 84.58,36.21 84.88,36.21 85.03,36.21 85.18,36.21 85.23,36.16 85.23,35.4 84.87,35.04 84.87,34.63 84.77,34.53 84.39,34.53 84.11,34.25 84.11,31.55 83.9,31.35 82.72,31.35 82.66,31.41 82.66,31.63 82.81,31.78 82.81,34.05 82.86,34.1 83.07,34.1 83.29,34.33 83.29,34.77 83.22,34.84 83.2,34.86 82.87,34.86 82.84,34.88 82.84,35.13 82.83,35.14 82.83,36.52 82.88,36.56 83.3,36.56
DVDD_PROC_B on IN1 (solid shape): 100.19,37.47 100.19,35.82 100.14,35.78 98.95,35.78 98.87,35.86 98.87,37.42 99.04,37.6 100.06,37.6
DVDD_PROC_B on IN1 (solid shape): 84.75,35.61 84.75,35.12 84.25,34.63 83.8,34.63 83.78,34.65 83.78,34.91 83.7,34.99 83.7,36 83.78,36.07 84.29,36.07
DVDD_PROC_B on IN2 (solid shape): 84.84,36.06 84.84,35.83 84.82,35.8 84.82,35.09 84.54,34.81 84.54,33.26 83.42,32.14 83.42,30.93 83.4,30.91 83.4,30.85 82.92,30.37 80.69,30.37 80.6,30.46 80.6,31.02 80.45,31.17 80.45,31.86 80.81,32.21 80.81,32.24 80.81,32.26 80.85,32.33 80.86,32.43 80.9,32.51 80.99,32.53 81.04,32.52 81.09,32.52 81.34,32.62 81.44,32.87 81.43,32.96 81.55,33.08 82.3,33.08 82.69,33.46 82.69,34.96 82.79,35.05 82.84,35.07 82.87,35.02 82.87,34.88 82.98,34.77 82.98,34.75 83.42,34.54 83.27,35 83.25,35 83.2,35.05 83.2,35.11 83.2,35.23 83.16,35.28 83.08,35.35 83.17,35.44 83.27,35.44 83.27,35.98 83.37,36.08 83.98,36.08 84.06,36.16 84.74,36.16
DVDD_PROC_B on IN2 (solid shape): outline of 415 points within 97.96,26.55 103.12,37.35
DVDD_PROC_B on IN3 (solid shape): outline of 650 points within 77.2,25.14 84.82,38.19
DVDD_PROC_B on IN4 (solid shape): 82.89,26.14 82.89,25.51 82.86,25.46 82.83,25.4 82.46,25.03 81.28,25.03 81.13,25.18 81.13,26.35 81.28,26.51 82.52,26.51
DVDD_PROC_B on IN4 (solid shape): 81.57,32.54 83.29,32.54 83.91,31.91 83.91,31.53 83.63,31.25 80.6,31.25 80.5,31.35 80.5,32.29 80.75,32.54 81.57,32.54
DVDD_PROC_B on IN4 (solid shape): 101.55,27.57 101.55,27.23 101.25,26.93 101.25,25.94 101.05,25.74 99.71,25.74 99.58,25.76 99.44,25.74 99.32,25.74 99.27,25.79 99.27,27.65 99.42,27.8 101.32,27.8
DVDD_PROC_B on IN4 (solid shape): 84.84,36.06 84.84,35.42 84.69,35.27 83.7,35.27 83.47,35.04 83.04,35.04 82.94,35.14 82.94,35.4 82.99,35.44 82.99,35.96 83.11,36.08 83.7,36.08 83.8,36.18 84.72,36.18
DVDD_PROC_B on IN5 (solid shape): 83.42,36.07 83.44,36.05 83.47,36.05 83.7,36.05 83.73,36.05 83.76,36.07 83.89,36.2 84.76,36.2 84.82,36.15 84.84,36.13 84.87,36.12 84.94,36.12 85.1,35.97 85.1,35.27 84.69,34.85 83.05,34.85 82.96,34.94 82.96,36.25 83.02,36.3 83.19,36.3
DVDD_PROC_B on IN5 (solid shape): outline of 126 points within 81.01,24.96 101.25,29.62
DVDD_PROC_L on TOP (solid shape): 100.24,40.35 100.24,38.42 100.13,38.32 98.59,38.32 98.5,38.4 98.5,39.77 98.38,39.88 98.38,40.48 98.46,40.55 100.03,40.55
DVDD_PROC_L on BOTTOM (solid shape): 81.71,42.23 81.71,39.42 81.58,39.29 81.18,39.29 81.07,39.39 81.07,42.23 81.2,42.36 81.58,42.36
DVDD_PROC_L on BOTTOM (solid shape): 83.02,38.44 84.84,38.44 84.96,38.31 84.96,38.04 85.31,37.69 85.31,37.49 85.3,37.47 85.02,37.47 84.97,37.42 82.87,37.42 82.87,37.63 82.68,37.63 82.66,37.66 82.66,37.73 82.29,38.1 82.29,38.55 82.37,38.63 82.83,38.63
DVDD_PROC_L on IN1 (solid shape): 84.78,37.2 84.78,36.71 84.68,36.61 83.83,36.61 83.73,36.71 83.73,37.22 83.54,37.41 83.34,37.41 83.29,37.46 83.29,37.66 83.32,37.7 84.28,37.7
DVDD_PROC_L on IN1 (solid shape): 100.22,40.36 100.22,38.71 100.16,38.65 98.97,38.65 98.89,38.72 98.89,39.39 98.89,39.39 98.89,39.54 98.41,40.02 98.41,40.26 98.42,40.3 98.41,40.34 98.41,40.48 98.48,40.55 100.03,40.55
DVDD_PROC_L on IN2 (solid shape): 100.16,40.13 100.16,38.87 100.04,38.76 99.87,38.76 99.8,38.7 98.99,38.7 98.33,39.36 98.33,40.4 98.43,40.51 99.78,40.51
DVDD_PROC_L on IN2 (solid shape): 84.01,38.05 84.01,37.85 84.14,37.72 84.33,37.72 84.45,37.84 84.71,37.84 84.82,37.72 84.82,37.16 84.33,36.67 84.18,36.67 84.01,36.84 83.76,36.84 83.66,36.94 83.66,37.35 83.59,37.42 83.17,37.42 83.1,37.5 83.1,38.06 83.17,38.14 83.92,38.14
DVDD_PROC_L on IN4 (solid shape): 99.82,40.86 99.82,38.74 99.72,38.63 97.87,38.63 97.48,39.03 97.48,39.71 97.49,39.76 97.49,39.81 97.49,39.86 97.48,39.9 97.48,40.83 97.61,40.96 99.72,40.96
DVDD_PROC_L on IN4 (solid shape): 84.07,38.08 84.63,38.08 85.07,37.64 85.07,37.5 85,37.44 84.82,37.44 84.45,37.07 84.22,37.07 83.99,36.84 83.85,36.84 83.69,37 83.69,37.41 83.6,37.49 83.33,37.49 83.11,37.71 83.11,38.09 83.37,38.35 83.8,38.35
DVDD_PROC_L on IN5 (solid shape): outline of 1664 points within 81.09,36.15 99.09,44.63
DVDD_SRAM_CORE on BOTTOM (solid shape): 110.85,44.41 110.85,43.76 110.71,43.62 109.84,43.62 109.56,43.9 109.56,44.41 109.61,44.46 110.81,44.46
DVDD_SRAM_PROC_B on BOTTOM (solid shape): 115.9,39.28 115.9,39.27 116.09,39.09 116.09,29.01 111.79,24.72 111.22,24.72 110.36,24.98 109.46,25.07 108.02,24.84 106.73,24.16 88.16,24.16 87.51,24.8 87.51,29.08 85.7,30.89 84.56,30.89 84.39,31.07 84.39,33.57 85.46,34.64 85.46,34.83 85.53,34.91 85.91,34.91 85.96,34.86 85.96,34.02 85.82,33.88 85.69,33.88 85.6,33.79 85.6,33.29 85.55,33.24 85.2,33.24 85.04,33.07 85.04,32.53 85.16,32.41 85.59,32.41 86.8,31.2 87.51,31.2 87.78,30.92 88.36,30.92 88.48,30.81 88.48,26.2 88.82,25.86 88.83,25.86 88.84,25.84 97.17,25.84 97.18,25.86 98.32,25.86 98.53,25.64 106.31,25.64 107.02,26.35 109.68,26.35 112.46,29.13 112.47,29.13 113.9,30.56 113.9,35.52 113.69,35.74 113.69,36.48 113.65,36.58 113.57,36.63 113.57,37.45 113.57,37.46 113.57,37.62 113.37,37.81 113.37,38.51 113.35,38.61 113.29,38.69 112.94,39.05 112.94,39.43 113.14,39.63 115.55,39.63
DVDD_SRAM_PROC_L on TOP (solid shape): 80.02,28.59 80.02,27.74 79.99,27.72 79.99,27.62 79.84,27.47 79.23,27.47 79.1,27.6 79.1,28.43 79.36,28.69 79.92,28.69
DVDD_SRAM_PROC_L on BOTTOM (solid shape): 82.48,36.89 82.48,36.74 82.18,36.44 82.18,36.11 81.77,35.7 81.77,33.82 81.97,33.62 81.97,30.14 79.93,28.1 79.23,28.1 79.13,28.2 79.13,29.72 80.17,30.76 80.17,36.67 80.55,37.05 82.33,37.05
DVDD_SRAM_PROC_L on IN4 (solid shape): outline of 217 points within 78.37,42.28 113.96,60.89
DVDD_SRAM_PROC_L on IN5 (solid shape): 79.48,58.5 79.48,57.59 78.67,56.78 78.34,56.78 78.29,56.77 78.25,56.74 76.6,55.09 76.57,55.05 76.56,55 76.56,50.68 76.57,50.63 76.6,50.59 77.96,49.23 77.96,48.49 77.91,48.4 77.82,48.39 77.76,48.41 77.71,48.42 77.43,48.14 77.71,47.86 77.76,47.87 77.82,47.88 77.91,47.88 77.96,47.79 77.96,35.31 77.97,35.26 78,35.22 80.25,32.97 80.25,27.62 80.07,27.44 77.51,27.44 74.79,30.16 74.79,54.94 78.52,58.68 79.31,58.68
DVDD_VSRAM_GPU_PMU on TOP (solid shape): 112.07,41.2 112.07,40.85 112,40.77 111.57,40.77 111.27,40.48 110.76,40.48 110.71,40.43 110.13,40.43 109.84,40.72 109.56,40.72 109.51,40.77 109.51,40.93 109.56,40.98 110.17,40.98 110.28,40.86 110.72,40.86 110.79,40.83 110.85,40.83 110.92,40.83 110.99,40.86 111.07,40.86 111.51,41.31 111.97,41.31
GND_VCORE on IN1 (solid shape): 104.68,43.07 104.68,42.44 104.69,42.43 104.69,42.2 104.64,42.13 104.63,42.04 104.64,41.96 104.68,41.88 104.69,41.87 104.69,41.75 104.62,41.73 104.55,41.77 104.26,41.63 104.57,41.57 104.58,41.58 104.62,41.61 104.67,41.58 104.69,41.55 104.71,41.48 104.68,41.41 104.38,41.11 104.38,40.93 104.53,40.78 104.53,40.42 104.43,40.32 104.03,40.32 103.98,40.37 103.98,40.39 103.92,40.46 103.92,40.68 103.51,41.08 103.51,42.63 104.05,43.17 104.58,43.17
GND_VDRAM1 on TOP (solid shape): 107.4,43.19 107.4,42.79 106.95,42.33 106.95,41.18 106.88,41.11 106.76,41.11 106.68,41.19 106.68,43.28 106.71,43.31 107.27,43.31
GND_VDRAM1 on IN1 (solid shape): 107.07,43.26 107.07,42.65 106.99,42.58 106.99,41.18 106.92,41.1 106.74,41.1 106.66,41.18 106.66,41.43 106.46,41.64 106.46,42.86 106.58,42.98 106.58,43.31 106.64,43.36 106.97,43.36
GND_VGPU on IN1 (solid shape): 103.82,40.65 103.82,40.32 103.89,40.25 104.53,40.25 104.86,40.58 105.32,40.58 105.37,40.53 105.37,39.94 105.1,39.67 105.06,39.69 104.91,39.71 104.79,39.62 104.78,39.59 104.68,39.59 104.59,39.61 104.52,39.61 103.79,39.61 103.47,39.94 103.47,40.01 103.39,40.2 103.2,40.28 103.13,40.27 103.07,40.25 103,40.27 102.94,40.28 102.87,40.27 102.8,40.25 102.74,40.27 102.68,40.28 102.48,40.2 102.4,40 102.41,39.93 102.27,39.79 101.63,39.79 101.51,39.92 101.51,40.58 102.14,41.21 103.26,41.21
GND_VMODEM on TOP (solid shape): 106.57,42.98 106.57,41.56 106.52,41.51 106.34,41.51 106.28,41.57 106.28,41.77 106.17,41.88 106.17,42.29 105.85,42.61 105.72,42.61 105.57,42.76 105.57,43.11 105.65,43.19 106.37,43.19
GND_VMODEM on IN1 (solid shape): 106.43,44.89 106.43,43.04 106.28,42.89 106.28,42.6 106.15,42.47 105.8,42.47 105.55,42.73 105.55,42.91 105.98,43.34 105.98,44.19 105.84,44.33 105.83,44.33 105.7,44.46 105.54,44.46 105.42,44.59 105.42,45 105.62,45.2 106.12,45.2
GND_VPROC11 on IN1 (solid shape): 102.04,38.31 102.32,38.31 102.37,38.26 102.37,37.2 102.27,37.1 101.58,37.1 101.48,37.2 101.48,38.11 101.68,38.31 102.04,38.31
GND_VPROC11 on IN1 (solid shape): 104.53,38.49 104.53,37.65 104.3,37.42 103.27,37.42 103.25,37.43 103.16,37.52 103.16,37.88 103.82,38.54 104.48,38.54
GND_VPROC12 on IN1 (solid shape): 105.14,39 105.29,39 105.37,38.93 105.37,38.37 105.29,38.29 104.99,38.29 104.61,38.67 103.84,38.67 103.77,38.75 103.77,39.36 103.87,39.46 104.68,39.46
GND_VPROC12 on IN1 (solid shape): 102.45,39.41 102.47,39.41 102.49,39.4 102.57,39.34 102.67,39.32 102.74,39.33 102.8,39.35 102.85,39.33 102.91,39.32 102.98,39.29 103,39.22 103,38.77 102.9,38.67 101.61,38.67 101.5,38.78 101.5,39.43 101.66,39.59 102.27,39.59
GND_VS1 on IN1 (solid shape): 104.57,36.5 104.57,35.69 104.35,35.47 104.31,35.44 104.27,35.39 104.23,35.35 103.32,35.35 103.27,35.41 103.27,35.86 104,36.59 104.48,36.59
GND_VS1 on IN1 (solid shape): 103.92,34.48 103.93,34.42 103.95,34.37 103.93,34.31 103.92,34.25 104,34.06 104.25,33.94 104.28,33.87 104.28,33.23 104.2,33.15 103.4,33.15 103.06,33.49 103.06,34.4 103.18,34.52 103.92,34.52
(no net) on GND: 13.45,39.59 14.42,40.34 13.96,41.47 13.96,46.28 14.42,47.41 13.45,48.16 2.71,48.16 2.71,48.26 1,48.26 0.65,48.4 0.51,48.75 0.51,51.22 3.9,51.22 5.03,50.75 5.78,51.73 5.78,60.68 5.03,61.65 3.9,61.18 0.51,61.18 0.51,62.4 0.65,62.75 1,62.89 17.2,62.89 18.25,62.46 18.69,61.4 18.69,52.9 19.43,51.13 21.2,50.39 56.5,50.39 58.27,51.13 59.01,52.9 59.01,65.5 60.03,67.97 62.5,68.99 148,68.99 148.35,68.85 148.49,68.5 148.49,64.69 152.3,64.69 152.65,64.55 152.79,64.2 152.79,6 152.35,4.94 151.3,4.51 88.1,4.51 87.03,4.07 86.59,3 86.59,1 86.45,0.65 86.1,0.51 9.2,0.51 8.14,0.94 7.71,2 7.71,20.51 4.2,20.51 3.14,20.95 2.71,22 2.71,39.59
AMP_L_EN on TOP (solid shape): 24.37,5.05 24.37,4.5 24.47,4.39 27.15,4.39 27.25,4.29 27.25,3.82 27.13,3.7 24.06,3.7 23.91,3.85 23.91,4.86 24.17,5.12 24.3,5.12
AMP_L_POWER on TOP (solid shape): 20.13,5.65 20.13,5.17 20.32,4.98 22.83,4.98 23.38,5.52 24.3,5.52 24.37,5.45 24.37,5.33 24.3,5.26 23.94,5.26 22.99,4.31 22.99,3.56 22.72,3.29 22.06,3.29 21.85,3.5 20.03,3.5 19.64,3.9 19.64,4.73 19.59,4.78 19.59,5.67 19.66,5.74 20.04,5.74
D_GND on TOP (solid shape): 14.46,15.78 12.12,15.78 12.12,18.12 14.46,18.12
D_GND on TOP (solid shape): 21.67,28.23 18.93,28.23 18.93,30.97 21.67,30.97
D_GND on TOP (solid shape): 32.72,17.43 24.24,17.43 24.24,25.99 32.72,25.99
D_GND on TOP (solid shape): 40.95,27.06 38.72,27.06 38.72,29.32 40.95,29.32
D_GND on TOP (solid shape): 48.65,16.92 44.23,16.92 44.23,20.43 48.65,20.43
D_GND on TOP (solid shape): 70.24,26.3 66.61,26.3 66.61,29.93 70.24,29.93
D_GND on TOP (solid shape): 126.09,30.99 123.3,30.99 123.3,33.79 126.09,33.79
D_GND on TOP (solid shape): 142.98,13.6 138.44,13.6 138.44,18.14 142.98,18.14
D_GND on TOP (solid shape): 69.79,5.04 69.66,4.91 69.17,4.91 68.99,5.09 68.99,8.81 69.79,8.81
D_GND on TOP (solid shape): 94.7,31.53 94.7,30.63 94.62,30.55 93.65,30.55 93.45,30.75 93.45,31.53 93.5,31.58 94.65,31.58
D_GND on TOP (solid shape): 112.3,50.51 112.83,50.51 112.91,50.43 112.91,50.22 112.74,50.05 111,50.05 110.62,50.43 110.62,50.66 110.72,50.76 112.05,50.76
D_GND on TOP (solid shape): 13.83,15.41 13.83,14.32 13.68,14.17 13.68,13.33 13.66,13.3 13.29,13.3 13.21,13.38 13.21,14.12 13.45,14.36 13.45,15.43 13.51,15.49 13.75,15.49
D_GND on TOP (solid shape): 41.52,48.35 41.52,47.26 41.49,47.22 41.49,46.13 41.44,46.09 40.41,46.09 40.34,46.16 40.34,47.61 40.11,47.83 40.11,48.32 40.27,48.47 41.41,48.47
D_GND on TOP (solid shape): 45.68,45.32 45.68,43.96 45.6,43.88 42.8,43.88 42.78,43.89 42.78,44.5 42.82,44.54 44.12,44.54 44.39,44.81 44.39,45.27 44.5,45.37 45.63,45.37
D_GND on TOP (solid shape): 108.13,26.89 109.49,26.89 109.84,26.55 109.84,26.31 109.78,26.25 107.85,26.25 107.81,26.3 107.81,26.55 107.42,26.93 107.42,27.26 107.48,27.31 107.71,27.31
D_GND on TOP (solid shape): 27.95,35.34 28.08,35.21 28.58,35.21 28.61,35.19 28.61,30.16 28.46,30 26.58,30 26.48,30.11 26.48,35.13 26.53,35.19 27.08,35.19 27.14,35.24 27.14,36.31 27.95,36.31
D_GND on TOP (solid shape): 129.27,41.15 129.27,39.75 128.85,39.32 127.8,39.32 127.34,38.87 126.41,38.87 126.3,38.97 126.3,39.64 126.2,39.74 125.46,39.74 125.32,39.88 125.32,40.46 126.25,41.38 129.04,41.38
D_GND on TOP (solid shape): 72.82,38.18 72.82,37.6 72.66,37.45 72.54,37.45 72.53,37.44 72.51,37.44 72.3,37.22 72.3,36.27 72.26,36.24 71.97,36.24 71.94,36.27 71.94,37.24 71.72,37.45 71.52,37.45 71.47,37.49 71.47,38.19 71.52,38.23 72.77,38.23
D_GND on TOP (solid shape): 83.98,30.33 83.98,29.6 83.62,29.25 83.62,28.68 82.89,27.95 81.41,27.95 81.39,27.95 80.88,27.44 80.37,27.44 80.23,27.58 80.23,30.02 80.37,30.16 81.47,30.16 81.59,30.16 81.82,30.38 83.93,30.38
D_GND on TOP (solid shape): 116.36,39.55 116.36,38.29 116.13,38.06 114.64,38.06 114.39,38.31 113.25,38.31 113.22,38.34 113.22,38.47 113.26,38.51 113.39,38.51 113.67,38.79 114.28,38.79 114.38,38.9 114.38,39.54 114.59,39.74 116.17,39.74
D_GND on TOP (solid shape): 122.66,16.9 122.66,16.64 122.79,16.52 123.81,16.52 123.93,16.39 123.93,16.14 122.88,16.14 122.54,15.79 122.54,14.99 122.41,14.87 120.25,14.87 120.12,14.99 120.12,17.02 120.25,17.15 122.41,17.15
D_GND on TOP (solid shape): 114.05,46.31 114.05,45.12 113.5,44.56 113.5,42.81 113.22,42.53 112.04,42.53 111.92,42.65 111.92,43.64 112.02,43.74 112.73,43.74 112.89,43.9 112.89,46.37 112.91,46.39 113.97,46.39
D_GND on TOP (solid shape): 116.45,56.64 116.45,54.61 116.36,54.52 115.8,54.52 115.8,54.56 115.18,54.56 115.17,54.57 115.17,54.76 115.8,54.76 115.8,54.96 115.17,54.96 115.17,55.16 115.8,55.16 115.8,55.36 115.17,55.36 115.17,55.74 115.19,55.74 115.19,56.33 115.17,56.33 115.17,56.48 115.47,56.78 116.31,56.78
D_GND on TOP (solid shape): 131.97,51.33 131.92,51.28 131.85,51.17 131.82,51.03 131.82,50.02 131.85,49.89 131.92,49.78 132.32,49.38 132.32,49.03 132.19,48.9 131.68,48.9 131.55,49.03 131.55,51.57 131.68,51.7 131.97,51.7
D_GND on TOP (solid shape): 93.66,35.74 93.66,35.74 93.8,35.59 95.46,35.59 95.5,35.63 95.64,35.63 95.69,35.63 95.8,35.53 95.8,35.32 95.64,35.17 95.03,35.17 94.52,34.66 94.52,34.13 94.53,34.12 94.53,33.55 94.41,33.43 93.93,33.43 93.79,33.57 93.79,34.36 92.72,35.44 92.72,35.88 92.85,36.01 93.39,36.01
D_GND on TOP (solid shape): 122.23,62.15 122.23,59.93 122.12,59.82 120.38,59.82 120.25,59.95 120.25,61.5 121.81,61.5 121.81,62.11 121.62,62.11 121.62,61.5 121.31,61.5 121.31,62.11 121.12,62.11 121.12,61.5 120.81,61.5 120.81,62.11 120.62,62.11 120.62,61.5 120.25,61.5 120.25,62.18 120.36,62.29 122.1,62.29
D_GND on TOP (solid shape): 80.86,52.89 80.17,52.21 79.28,52.21 79.23,52.2 79.19,52.17 78.3,51.28 78.28,51.25 78.21,51.25 78.21,51.58 79.1,52.47 80.03,52.47 80.07,52.48 80.11,52.5 80.42,52.81 80.44,52.85 80.45,52.89 80.45,52.91 80.53,52.95 80.59,52.92 80.65,52.91 80.72,52.92 80.78,52.95 80.79,52.96 80.86,52.96
D_GND on TOP (solid shape): 35.54,48.22 35.54,47.78 35.42,47.66 35.42,47.63 35.29,47.5 35.29,46.9 35.25,46.89 35,46.75 34.91,46.49 34.97,46.28 35.13,46.13 35.18,46.05 35.15,45.97 35.01,45.83 34.4,45.83 34.27,45.95 34.27,46.36 33.97,46.67 33.27,46.67 33.09,46.84 33.09,48.42 35.34,48.42
D_GND on TOP (solid shape): 87.26,31.04 88.02,31.04 88.13,30.93 88.13,30.48 88.12,30.46 88.12,30.32 87.75,29.95 87.69,29.95 87.49,29.87 87.41,29.67 87.42,29.62 87.2,29.4 87.19,29.39 86.34,29.39 86.33,29.38 86.21,29.38 86.04,29.22 86.04,27.9 85.99,27.84 85.78,27.84 85.73,27.9 85.73,29.89 85.78,29.94 86.33,29.94 86.39,30.01 86.39,30.69 86.27,30.82 85.1,30.82 84.97,30.68 84.97,30.11 84.87,30.01 84.56,30.01 84.49,30.08 84.49,31.07 84.62,31.2 87.11,31.2
D_GND on TOP (solid shape): 87.27,35.91 87.6,35.91 87.63,35.9 87.65,35.88 87.7,35.81 87.77,35.77 87.78,35.76 87.95,35.6 87.96,35.56 87.95,35.52 87.78,35.36 87.73,35.34 87.56,35.34 87.16,34.94 86.74,34.94 86.69,34.96 86.52,35.12 86.51,35.16 86.52,35.2 86.69,35.36 86.7,35.37 86.84,35.56 86.7,35.75 86.69,35.76 86.62,35.82 86.61,35.88 86.66,35.91 86.8,35.91 87,36.11 87.07,36.11
D_GND on TOP (solid shape): 86.8,41.03 86.83,41.05 86.87,41.03 86.99,40.96 87.13,40.98 87.14,40.98 87.61,40.98 87.64,40.98 87.66,40.95 87.67,40.93 87.68,40.9 87.67,40.88 87.65,40.85 87.61,40.81 87.61,39.44 87.55,39.35 87.44,39.37 87.1,39.71 86.77,39.71 86.74,39.74 86.69,39.76 86.52,39.92 86.51,39.96 86.52,40 86.69,40.16 86.7,40.17 86.82,40.28 86.82,40.45 86.81,40.46 86.81,40.66 86.82,40.67 86.84,40.79 86.79,40.89 86.76,40.96 86.79,41.03
D_GND on TOP (solid shape): 87.56,54.44 87.61,54.53 87.71,54.53 87.76,54.51 87.81,54.51 87.86,54.51 88.11,54.26 88.14,54.24 88.18,54.23 88.56,54.23 88.69,54.1 88.69,53.99 88.62,53.99 88.6,54.01 88.54,54.06 88.45,54.08 88.27,53.89 88.45,53.71 88.5,53.71 88.54,53.73 88.64,53.73 88.69,53.64 88.69,51.44 88.65,51.36 88.56,51.35 88.53,51.36 88.46,51.36 88.22,51.59 88.22,53.57 88.22,53.6 88.2,53.63 87.99,53.84 87.99,53.89 87.94,54.03 87.81,54.08 87.76,54.08 87.71,54.06 87.61,54.06 87.56,54.15
D_GND on TOP (solid shape): 92.14,49.38 92.17,49.37 92.19,49.37 92.43,49.37 92.67,49.12 92.67,47.34 91.51,46.17 91.12,46.17 91.12,46.25 91.17,46.28 91.19,46.29 92.11,47.21 92.14,47.25 92.15,47.3 92.15,47.32 92.23,47.35 92.29,47.32 92.35,47.31 92.54,47.49 92.35,47.68 92.32,47.68 92.29,47.67 92.19,47.68 92.15,47.76 92.15,48.03 92.19,48.11 92.29,48.12 92.32,48.11 92.35,48.11 92.54,48.3 92.35,48.48 92.32,48.48 92.29,48.47 92.19,48.48 92.15,48.56 92.15,48.87 92.14,48.91 92.12,48.95 92.12,49.22 92.12,49.26 92.1,49.29 92.05,49.34 92.11,49.4
D_GND on TOP (solid shape): 80.17,53.71 80.21,53.62 80.21,52.94 79.98,52.71 79.05,52.71 79,52.7 78.96,52.67 78,51.71 77.98,51.69 77.91,51.69 77.91,52.8 78.45,53.35 78.63,53.35 78.63,53.27 78.61,53.25 78.54,53.19 78.52,53.09 78.7,52.91 78.89,53.09 78.89,53.15 78.86,53.19 78.86,53.3 78.95,53.35 79.11,53.35 79.2,53.3 79.2,53.19 79.17,53.15 79.17,53.09 79.35,52.91 79.54,53.09 79.52,53.19 79.45,53.25 79.43,53.27 79.43,53.35 79.58,53.35 79.62,53.36 79.66,53.38 79.99,53.71 80.04,53.71 80.07,53.72
D_GND on TOP (solid shape): 84.07,48.11 84.11,48.03 84.11,46.46 84.06,46.41 83.54,46.93 83.51,47.01 83.54,47.08 83.59,47.14 83.61,47.21 83.6,47.24 83.6,47.27 83.6,47.31 83.58,47.38 83.55,47.43 83.44,47.54 83.43,47.55 83.37,47.65 83.25,47.68 83.12,47.63 83.07,47.49 83.07,47.47 83.08,47.44 83.06,47.35 82.98,47.31 82.23,47.31 82.15,47.35 82.13,47.44 82.14,47.48 82.17,47.52 82.21,47.52 82.25,47.51 82.28,47.51 82.4,47.56 82.45,47.68 82.45,47.72 82.58,47.85 83.55,47.85 83.59,47.86 83.62,47.88 83.85,48.11 83.94,48.11 83.97,48.12
D_GND on TOP (solid shape): 6.81,51.97 7.02,51.86 7.25,51.82 7.5,51.86 7.73,51.97 9.84,51.97 10.21,51.6 10.21,50.54 10.45,50.3 11.21,50.3 11.48,50.04 11.48,49.21 11.33,49.06 11.33,48.18 11.3,48.16 5.92,48.16 6.06,48.39 6.11,48.65 5.89,49.18 5.36,49.4 4.54,49.4 4.01,49.18 3.79,48.65 3.84,48.39 3.98,48.16 2.71,48.16 2.71,48.26 1,48.26 0.65,48.4 0.51,48.75 0.51,51.22 3.9,51.22 5.03,50.75 5.78,51.73 5.78,51.97 6.68,51.97 6.68,51.97
D_GND on TOP (solid shape): 80.17,54.51 80.21,54.43 80.21,54.16 80.17,54.08 80.07,54.07 80.04,54.08 80,54.08 79.87,54.03 79.82,53.9 79.82,53.88 79.53,53.59 78.4,53.59 78.36,53.58 78.32,53.55 77.72,52.96 77.67,52.95 77.64,52.99 77.64,53.11 78.37,53.84 78.46,53.87 78.54,53.82 78.6,53.74 78.7,53.71 78.84,53.76 78.89,53.89 78.88,53.96 78.85,54.01 78.84,54.12 78.93,54.17 79.13,54.17 79.22,54.12 79.21,54.01 79.18,53.96 79.17,53.89 79.35,53.71 79.54,53.89 79.53,53.96 79.5,54.01 79.49,54.12 79.58,54.17 79.6,54.17 79.65,54.18 79.69,54.21 79.99,54.51 80.04,54.51 80.07,54.52
D_GND on TOP (solid shape): 88.82,37.03 88.86,37.02 88.87,37 88.89,36.96 88.87,36.92 88.81,36.78 88.85,36.62 88.87,36.56 88.81,36.36 88.87,36.16 88.85,36.1 88.81,35.95 88.89,35.74 88.87,35.68 88.83,35.58 88.85,35.47 88.86,35.46 88.86,35.26 88.85,35.25 88.83,35.13 88.89,35.01 88.91,34.97 88.89,34.94 88.87,34.92 88.83,34.91 88.8,34.92 88.65,34.99 88.5,34.94 88.44,34.92 88.37,34.94 88.22,34.99 88.07,34.92 88.04,34.91 88,34.92 87.98,34.94 87.96,34.97 87.98,35.01 88.01,35.05 88.03,35.11 88.29,35.36 88.3,35.37 88.44,35.56 88.3,35.75 88.29,35.76 88.22,35.82 88.21,35.88 88.26,35.91 88.39,35.91 88.67,36.18 88.67,36.54 88.5,36.71 88.49,36.72 88.49,36.74 88.49,36.8 88.65,36.96 88.66,36.96 88.73,36.98 88.78,37.02
D_GND on TOP (solid shape): 90.06,44.1 90.16,44.09 90.21,44.01 90.21,43.72 90.48,43.46 90.52,43.4 90.53,43.37 90.5,43.32 90.45,43.33 90.39,43.36 90.32,43.37 90.28,43.39 90.24,43.39 90.07,43.32 90.01,43.16 90.02,43.08 90.07,43 90.08,42.98 90.07,42.92 90.02,42.91 89.99,42.93 89.85,42.99 89.7,42.94 89.63,42.92 89.57,42.95 89.55,42.99 89.56,43.02 89.57,43.03 89.57,43.29 89.31,43.3 89.23,43.27 89.16,43.3 89.14,43.32 89.11,43.36 89.14,43.4 89.15,43.41 89.21,43.49 89.22,43.58 89.22,43.61 89.51,43.9 89.59,43.93 89.67,43.87 89.7,43.83 89.73,43.76 89.7,43.69 89.66,43.63 89.65,43.56 89.83,43.37 90.02,43.56 90.01,43.63 89.97,43.69 89.94,43.76 89.97,43.83 90.02,43.92 90.01,44.01 90.01,44.04 90.04,44.09
D_GND on TOP (solid shape): 86.95,42.15 87.03,42.13 87.12,42.15 87.13,42.15 87.34,42.15 87.35,42.15 87.43,42.13 87.52,42.15 87.53,42.15 87.74,42.15 87.75,42.15 87.83,42.13 87.92,42.15 87.93,42.15 87.99,42.15 88.03,42.14 88.04,42.1 88.04,42.08 88.08,41.79 88.37,41.78 88.44,41.8 88.5,41.78 88.65,41.73 88.86,41.83 88.93,41.8 88.98,41.78 88.99,41.75 88.99,41.58 89.02,41.55 89.05,41.45 88.98,41.38 88.93,41.36 88.88,41.33 88.82,41.31 88.75,41.32 88.53,41.33 88.43,41.13 88.41,41.04 88.33,41.01 88.14,41.01 88.06,41.04 88.04,41.13 87.96,41.32 87.74,41.34 87.72,41.34 87.63,41.38 87.62,41.48 87.51,41.75 87.24,41.63 87.17,41.56 87.08,41.59 86.93,41.74 86.85,41.79 86.85,41.88 86.86,41.97 86.84,42.06 86.83,42.1 86.85,42.12 86.88,42.15 86.94,42.15
D_GND on TOP (solid shape): 87.58,38.8 87.6,38.76 87.38,38.52 87.38,38.18 87.37,38.15 87.35,38.15 87.26,38.07 87.23,37.96 87.29,37.82 87.43,37.76 87.5,37.77 87.57,37.81 87.61,37.83 87.65,37.81 87.67,37.79 87.68,37.76 87.68,37.7 87.67,37.68 87.64,37.5 87.77,37.37 87.78,37.36 87.95,37.2 87.96,37.16 87.95,37.12 87.78,36.96 87.77,36.95 87.63,36.76 87.77,36.57 87.78,36.56 87.85,36.5 87.86,36.44 87.81,36.41 87.67,36.41 87.47,36.21 87.4,36.21 87.2,36.41 86.87,36.41 86.84,36.42 86.76,36.52 86.66,36.56 86.65,36.56 86.5,36.71 86.49,36.74 86.5,36.78 86.69,36.96 86.7,36.97 86.84,37.16 86.7,37.35 86.69,37.36 86.52,37.52 86.51,37.56 86.52,37.6 86.69,37.76 86.7,37.77 86.84,37.96 86.7,38.15 86.69,38.16 86.52,38.32 86.51,38.36 86.52,38.4 86.69,38.56 86.7,38.57 86.84,38.76 86.7,38.95 86.69,38.96 86.52,39.13 86.51,39.16 86.69,39.36 86.74,39.38 86.77,39.41 86.97,39.41
D_GND on TOP (solid shape): outline of 166 points within 89.43,47.06 91.09,49.74
D_GND on TOP (solid shape): outline of 102 points within 54.15,15.75 56.24,18.17
D_GND on TOP (solid shape): outline of 95 points within 84.89,36.87 86.46,40.91
D_GND on TOP (solid shape): outline of 307 points within 76.81,44.06 85.82,59.82
D_GND on TOP (solid shape): outline of 362 points within 74.04,22.59 118.63,67.44
D_GND on TOP (solid shape): outline of 391 points within 85.91,45.51 87.8,55.78
D_GND on TOP (solid shape): outline of 658 points within 77.34,51.98 84.13,56.54
D_GND on TOP (solid shape): outline of 1155 points within 0.51,0.51 152.79,68.99
D_GND on TOP (solid shape): outline of 1053 points within 78.51,47.31 84.11,53.73
D_GND on TOP (solid shape): outline of 1419 points within 79.87,42.36 107.91,62.95
D_GND on TOP (solid shape): outline of 1325 points within 79.44,32.58 86.86,43.99
D_GND on BOTTOM (solid shape): 20.35,14.48 17.46,14.48 17.46,18.17 20.35,18.17
D_GND on BOTTOM (solid shape): 65.79,35.44 62.19,35.44 62.19,38.36 65.79,38.36
D_GND on BOTTOM (solid shape): 68.69,20.68 65.72,20.68 65.72,23.27 68.69,23.27
D_GND on BOTTOM (solid shape): 70.58,22.1 70.58,21.33 70.49,21.24 69.22,21.24 69.12,21.34 69.12,22.56 69.32,22.76 69.92,22.76
D_GND on BOTTOM (solid shape): 129.9,59.18 129.9,56.95 129.8,56.85 129.8,56.51 129.74,56.44 129.59,56.44 129.28,56.75 129.28,56.91 129.4,57.02 129.4,59.19 129.5,59.29 129.79,59.29
D_GND on BOTTOM (solid shape): 49.08,28.68 51.19,28.68 51.29,28.58 51.29,27.03 50.96,26.7 43.7,26.7 43.01,27.39 43.01,28.61 43.11,28.71 46.49,28.71 46.72,28.94 48.83,28.94
D_GND on BOTTOM (solid shape): 95.8,21.33 95.8,19.73 96.02,19.51 96.02,18.9 95.94,18.83 94.95,18.83 94.68,19.1 94.68,19.35 94.37,19.67 91.91,19.67 91.85,19.72 91.85,20.62 92.78,21.55 95.59,21.55
D_GND on BOTTOM (solid shape): 111.39,47.16 111.39,45.56 110.93,45.1 110.93,45.08 110.83,44.97 108.64,44.97 108.29,44.62 105.92,44.62 105.9,44.64 105.9,47.36 105.98,47.44 105.98,47.92 106.05,47.99 110.55,47.99
D_GND on BOTTOM (solid shape): 63.56,32.39 63.56,26.96 63.08,26.47 61.91,26.47 61.6,26.78 61.6,32.09 61.15,32.54 61.15,33.05 61.25,33.15 62.8,33.15
D_GND on BOTTOM (solid shape): 101.2,21.22 101.2,20.58 100.67,20.05 100.67,17.24 100.3,16.87 98.28,16.87 98.23,16.92 98.23,17.46 98.28,17.51 99.3,17.51 99.42,17.63 99.42,19.61 99.55,19.74 99.55,20.07 100.82,21.34 101.07,21.34
D_GND on BOTTOM (solid shape): 125.59,33.59 125.59,33.28 125.43,33.13 125.43,31.25 125.3,31.11 123.54,31.11 123.4,31.25 123.4,31.51 123.29,31.61 122.81,31.61 122.78,31.64 122.78,32.23 123.01,32.46 123.01,33.54 123.21,33.74 125.43,33.74
D_GND on BOTTOM (solid shape): 95.14,31.69 95.14,30.71 93.22,28.79 88.72,28.79 88.63,28.88 88.63,30.73 88.82,30.92 89.55,30.92 90.41,31.79 94.55,31.79 94.55,31.8 95.04,31.8
D_GND on BOTTOM (solid shape): 91.11,17.98 91.1,17.97 91.1,17.44 91.06,17.41 90.64,17.41 90.56,17.33 90.56,16.41 90.64,16.34 91.8,16.34 91.93,16.21 91.93,15.3 91.78,15.14 88.83,15.14 88.77,15.21 88.77,16.1 88.48,16.39 88.48,17.96 88.56,18.04 91.04,18.04
D_GND on BOTTOM (solid shape): 30.38,34.59 30.38,32.33 27.44,29.39 23.58,29.39 23.53,29.34 23.53,28.1 23.43,28 19.59,28 18.98,28.61 18.98,33.71 19.34,34.07 24.85,34.07 25.89,35.11 29.86,35.11
D_GND on BOTTOM (solid shape): 129.12,42.04 133.54,42.04 133.82,41.76 133.82,39.68 132.39,38.26 132.39,37.5 131.71,36.81 131.07,36.81 131,36.89 131,40.06 130.84,40.21 125.1,40.21 124.75,40.57 117.18,40.57 117.03,40.72 117.03,42.14 117.1,42.22 128.94,42.22
D_GND on BOTTOM (solid shape): 23.81,18.22 23.81,16.53 23.71,16.43 22.98,16.43 22.93,16.48 22.93,17.66 22.81,17.77 21.9,17.77 21.74,17.62 21.74,17.44 21.74,17.44 21.74,16.47 21.66,16.4 21.16,16.4 21.09,16.47 21.09,18.19 21.21,18.32 21.8,18.32 21.8,18.32 23.71,18.32
D_GND on BOTTOM (solid shape): 61.6,15.5 65.95,15.5 65.97,15.47 65.97,14.74 66.12,14.59 67.45,14.59 68.36,13.67 68.36,9.91 68.49,9.79 70.06,9.79 70.07,9.8 71.14,9.8 71.43,10.09 71.43,11.03 71.59,11.18 76.23,11.18 76.46,11.41 76.46,14.53 76.26,14.74 76.26,15.5 76.41,15.65 78.88,15.65 79,15.53 79,12.22 73.67,6.89 67.72,6.89 64.58,10.04 64.58,12.39 63.5,13.47 61.72,13.47 61.06,14.13 59.25,14.13 58.85,14.53 57.91,14.53 57.86,14.58 57.86,15.8 57.89,15.83 61.27,15.83
D_GND on BOTTOM (solid shape): outline of 83 points within 119.72,26.04 128.13,30.93
D_GND on BOTTOM (solid shape): 65.49,42.25 65.69,42.25 65.77,42.17 65.77,42.04 65.64,41.92 65.13,41.92 65.01,41.79 65.01,41.41 65.03,41.38 65.03,41.34 65.18,41.2 65.27,41.21 65.38,41.21 65.55,41.21 65.65,41.21 65.67,41.17 65.67,40.59 65.72,40.49 65.72,40.19 65.69,40.05 65.52,39.88 64.75,39.88 64.68,39.96 64.56,40.25 64.27,40.37 64.02,40.28 63.87,40.05 63.86,40.01 62.97,40.01 62.92,40.06 62.92,40.62 63,40.7 63.71,40.7 63.97,40.95 64.42,40.95 64.5,41.03 64.5,42.17 64.57,42.25 64.7,42.25 64.76,42.25 65.44,42.25
D_GND on BOTTOM (solid shape): 6.81,51.97 7.05,51.85 7.32,51.82 7.48,51.83 7.63,51.87 9,50.5 9,50.04 9.28,49.76 9.74,49.76 10.33,49.17 11.64,49.17 11.64,48.16 5.78,48.16 5.95,48.38 6,48.65 5.81,49.11 5.36,49.3 4.54,49.3 4.09,49.11 3.9,48.65 3.95,48.38 4.12,48.16 2.71,48.16 2.71,48.26 1,48.26 0.65,48.4 0.51,48.75 0.51,51.22 3.9,51.22 5.03,50.75 5.78,51.73 5.78,51.97 6.64,51.97 6.64,51.97
D_GND on BOTTOM (solid shape): 106.95,35.02 106.95,35 107.13,34.77 107.42,34.82 107.45,34.83 107.49,34.82 107.86,34.45 107.86,33.38 107.65,33.18 99.07,33.18 98.94,33.31 98.94,34.46 99,34.55 99.11,34.53 99.18,34.47 99.18,34.44 99.16,34.42 99.39,33.97 99.57,34.44 99.57,34.55 99.55,34.63 99.51,34.7 99.36,34.84 99.34,34.95 99.43,35.01 100.35,35.01 100.39,34.98 100.38,34.93 100.28,34.83 100.27,34.83 100.08,34.74 100.01,34.55 100.09,34.35 100.29,34.27 100.47,34.35 100.56,34.53 100.56,34.55 101.08,35.07 106.9,35.07
D_GND on BOTTOM (solid shape): outline of 229 points within 81.9,33.06 90.64,37.43
D_GND on BOTTOM (solid shape): outline of 567 points within 92.95,29.42 113.39,47.89
D_GND on BOTTOM (solid shape): outline of 838 points within 29.98,15.99 41.51,26.73
D_GND on BOTTOM (solid shape): outline of 1264 points within 0.51,0.51 152.79,68.99
D_GND on BOTTOM (solid shape): outline of 1181 points within 73.27,37.15 99.04,60.76
D_GND on IN1 (solid shape): 113.26,50.61 113.26,50.21 112.93,49.89 107.42,49.89 107.42,50.69 107.59,50.86 113.01,50.86
D_GND on IN1 (solid shape): 99.74,33.57 99.74,32.53 99.64,32.42 99.43,32.42 98.86,32.99 98.86,33.65 99.05,33.84 99.47,33.84
D_GND on IN1 (solid shape): 101.35,40.38 101.35,38.47 101.1,38.22 100.46,38.22 100.39,38.29 100.39,40.43 100.46,40.5 101.22,40.5
D_GND on IN1 (solid shape): 94.7,31.41 94.7,30.73 94.63,30.66 93.74,30.66 93.6,30.8 93.47,30.8 93.43,30.84 93.43,31.51 93.53,31.61 94.5,31.61
D_GND on IN1 (solid shape): 112.26,44.4 112.26,43.69 112.49,43.46 112.49,42.77 112.31,42.58 112.09,42.58 111.95,42.72 111.95,43.46 111.92,43.49 111.92,43.64 111.57,43.99 110.26,43.99 110.09,43.82 110.09,43.69 110.04,43.64 109.81,43.64 109.77,43.69 109.77,44.07 109.86,44.16 109.86,44.16 110.67,44.97 111.69,44.97
D_GND on IN1 (solid shape): 84.36,41.62 84.36,41.01 84.38,40.99 84.38,38.7 84.33,38.65 84.15,38.65 83.81,38.99 82.96,38.99 82.96,38.98 82.88,38.98 82.88,39.66 82.9,39.67 82.92,39.7 82.93,39.74 82.93,40.7 83.21,40.99 83.67,40.99 84.05,41.37 84.05,41.67 84.13,41.75 84.23,41.75
D_GND on IN1 (solid shape): 66.71,39.15 66.71,37.41 66.39,37.09 66.39,36.47 66.29,36.37 66.25,36.23 66.27,36.14 66.31,36.06 66.31,36.05 66.31,35.96 65.82,35.46 62.16,35.46 62.14,35.49 62.14,37.82 61.76,38.2 61.76,38.49 63.84,38.49 64.65,39.3 66.56,39.3
D_GND on IN1 (solid shape): 74.03,39.83 74.14,39.7 74.29,39.65 74.43,39.69 74.53,39.79 75.62,39.79 75.98,39.44 75.98,34.73 75.85,34.59 74.73,34.59 74.25,35.08 74.25,36.52 74.23,36.6 74.19,36.66 73.88,36.97 73.88,39.82 73.92,39.86 74.02,39.86
D_GND on IN1 (solid shape): 107.15,36.09 107.16,36.06 107.15,36.04 106.98,35.86 106.98,31.06 107.31,30.73 107.31,29.97 107.4,29.88 107.4,28.66 106.37,27.63 106.17,27.63 105.99,27.45 105.99,27.13 105.95,27.1 105.91,27.13 105.91,27.48 106.14,27.7 106.34,27.7 107.33,28.69 107.33,29.85 107.23,29.94 107.23,30.7 106.9,31.03 106.9,35.9 107.1,36.09 107.13,36.1
D_GND on IN1 (solid shape): 72.89,37.61 72.89,35.25 74.53,33.61 75,33.61 75.23,33.38 75.23,31.3 75.51,31.01 75.54,30.93 75.49,30.86 75.35,30.57 75.57,30.34 75.61,30.33 75.61,29.69 75.34,29.42 74.82,29.42 74.68,29.55 74.68,30.87 72.58,32.98 70.45,32.98 70.01,33.41 68.08,33.41 67.16,32.49 64.6,32.49 62.62,34.48 62.62,34.51 62.85,34.74 66.22,34.74 67.48,36 67.48,37.48 67.54,37.53 70.73,37.53 70.74,37.52 71.62,37.52 72.11,38.01 72.49,38.01
D_GND on IN1 (solid shape): 11.48,29.46 11.52,29.35 11.59,29.25 11.59,29.06 11.41,28.87 11.33,28.76 11.3,28.62 11.3,28.07 11.66,27.72 12.01,28.07 12.01,28.48 12.2,28.66 12.28,28.78 12.3,28.91 12.3,29.4 12.3,29.49 13.48,29.49 14.17,28.81 14.17,27.75 14.01,27.59 11.45,27.59 10.57,28.47 10.57,29.39 10.68,29.5 11.48,29.5
D_GND on IN1 (solid shape): 103.07,35.86 102.95,35.74 102.83,35.57 102.77,35.37 102.73,35.3 102.65,35.28 102.62,35.29 102.35,35.01 102.62,34.73 102.65,34.73 102.73,34.7 102.76,34.63 102.76,34.22 102.8,34 102.9,33.81 102.9,33.43 103.33,33 103.41,33 103.42,32.99 103.91,32.99 103.92,33 104.2,33 104.28,32.92 104.28,32.41 104.24,32.37 103.76,32.37 103.51,32.12 103.51,31.74 103.38,31.61 101.11,31.61 100.84,31.88 100.84,35.42 101.35,35.93 101.57,35.93 101.7,35.8 102.36,35.8 102.5,35.94 102.5,36.06 102.87,36.06
D_GND on IN1 (solid shape): 109.75,32.69 109.82,32.65 109.89,32.63 111.19,32.63 111.27,32.59 111.28,32.49 111.27,32.44 111.26,32.39 111.34,32.19 111.54,32.11 111.72,32.18 111.81,32.35 111.82,32.39 111.8,32.5 111.73,32.59 111.73,32.73 111.78,32.78 112.13,32.44 112.19,32.39 112.27,32.37 112.3,32.35 112.3,29.63 112.07,29.4 109.1,29.4 108.94,29.56 108.94,30.54 108.97,30.55 109.08,30.65 109.13,30.8 109.12,30.85 109.1,30.91 109.1,32.16 109.09,32.24 109.04,32.31 108.67,32.68 108.67,32.81 108.82,32.96 109.48,32.96
D_GND on IN1 (solid shape): 92.86,37 92.95,36.98 93.03,36.93 93.12,36.91 93.15,36.91 93.19,36.92 93.26,36.91 93.3,36.86 93.32,36.84 93.2,36.73 93.15,36.58 93.23,36.39 93.43,36.3 93.49,36.31 93.55,36.33 93.59,36.3 93.59,35.84 93.67,35.77 93.67,34.79 93.69,34.72 93.73,34.66 94.08,34.3 94.08,33.3 94.12,33.26 94.12,33.24 94.25,33.1 94.19,33.04 94.16,33.04 94.15,33.03 93.97,33.03 93.97,33.04 93.57,33.04 93.42,33.19 93.42,33.34 93.5,33.53 93.42,33.73 93.42,34.1 93.27,34.25 93.27,34.81 93.42,34.97 93.42,35.03 93.43,35.05 93.44,35.1 93.45,35.14 93.44,35.19 93.42,35.25 93.42,35.35 93.41,35.36 93.41,35.37 93.18,35.6 93.18,35.62 93.17,35.69 93.12,35.75 93.12,36.02 92.51,36.64 92.49,36.75 92.58,36.81 92.7,36.85 92.79,36.95
D_GND on IN1 (solid shape): 97.48,27.92 97.51,27.92 99.39,26.04 99.39,25.78 99.27,25.66 97.92,25.66 97.66,25.92 96.99,26.58 96.92,26.63 96.83,26.65 96.27,26.65 96.04,26.88 96.04,26.9 95.94,27.05 95.77,27.11 95.63,27.07 95.53,26.98 95.46,26.93 95.37,26.96 95.31,27.03 95.28,27.1 95.31,27.17 95.38,27.27 95.41,27.38 95.32,27.58 95.13,27.66 94.98,27.62 94.88,27.5 94.8,27.44 94.71,27.47 94.33,27.85 94.26,27.89 94.19,27.91 93.99,27.91 93.71,28.19 93.71,28.76 93.82,28.87 95.69,28.87 96.04,28.52 96.03,28.49 96.31,28.21 96.59,28.49 96.52,28.68 96.35,28.77 96.33,28.77 96.24,28.86 96.23,28.91 96.28,28.95 96.45,28.95
D_GND on IN1 (solid shape): 88.83,39.83 88.89,39.8 88.93,39.78 88.95,39.74 88.93,39.69 88.86,39.57 88.92,39.44 88.95,39.36 88.92,39.29 88.87,39.17 88.92,38.98 88.82,38.77 88.87,38.63 88.89,38.56 88.82,38.36 88.89,38.16 88.87,38.1 88.9,37.8 89.19,37.82 89.26,37.85 89.45,37.79 89.56,37.84 89.64,37.88 89.71,37.84 89.72,37.84 89.75,37.76 89.72,37.69 89.68,37.63 89.66,37.57 89.63,37.5 89.56,37.47 89.51,37.47 89.49,37.45 88.86,37.45 88.73,37.32 88.7,37.32 88.69,37.32 88.63,37.33 88.55,37.32 88.53,37.32 88.5,37.34 88.49,37.37 88.49,37.44 88.27,37.66 88.26,37.69 88.26,37.72 88.29,37.75 88.31,37.76 88.41,37.84 88.45,37.96 88.45,37.98 88.46,37.99 88.49,38.02 88.49,39.55 88.72,39.78 88.76,39.81
D_GND on IN1 (solid shape): outline of 148 points within 101.5,41.37 108.26,49.16
D_GND on IN1 (solid shape): 92.09,38.61 92.19,38.55 92.17,38.44 92.11,38.35 92.08,38.24 92.11,38.11 92.2,38.02 92.19,37.98 92.19,37.94 92.27,37.74 92.46,37.66 92.54,37.67 92.61,37.7 92.64,37.71 92.67,37.69 92.76,37.63 92.87,37.61 93.07,37.69 93.15,37.88 93.14,37.96 93.11,38.03 93.13,38.09 93.14,38.15 93.06,38.34 92.88,38.41 92.8,38.4 92.73,38.37 92.66,38.35 92.59,38.4 92.56,38.44 92.54,38.55 92.63,38.61 92.95,38.61 93.24,38.32 93.24,38.3 93.26,38.25 93.29,38.21 93.29,37.53 93.25,37.46 93.17,37.43 93.12,37.44 92.99,37.4 92.89,37.3 92.82,37.25 92.73,37.27 92.65,37.32 92.56,37.34 92.5,37.33 92.44,37.31 92.37,37.3 92.31,37.34 92.21,37.42 92.08,37.45 91.89,37.37 91.8,37.17 91.84,37.04 91.93,36.94 91.95,36.93 91.95,36.85 91.82,36.85 91.72,36.94 90.76,36.94 90.62,37.09 90.62,37.32 90.44,37.49 90.44,37.6 90.44,37.92 90.44,38.03 90.87,38.45 91.67,38.45 91.83,38.61
D_GND on IN1 (solid shape): outline of 306 points within 122.46,21.9 130.03,36.13
D_GND on IN1 (solid shape): outline of 338 points within 44.75,34.24 55.04,40.8
D_GND on IN1 (solid shape): outline of 497 points within 57.77,39.12 64.38,43.69
D_GND on IN1 (solid shape): outline of 790 points within 63.99,36.94 82.75,46.87
D_GND on IN1 (solid shape): outline of 1047 points within 78.93,24.92 87.55,40.99
D_GND on IN1 (solid shape): outline of 33263 points within 0.51,0.51 152.79,68.99
D_GND on IN2 (solid shape): 11.4,48.16 6.45,48.16 6.36,48.24 6.36,49.17 11.4,49.17
D_GND on IN2 (solid shape): 67.72,13.82 67.72,13.45 67.51,13.24 66.53,13.24 66.2,13.57 66.2,13.9 66.7,14.39 67.14,14.39
D_GND on IN2 (solid shape): 94.95,31.53 94.95,30.79 94.79,30.63 93.77,30.63 93.44,30.96 93.44,31.49 93.54,31.59 94.89,31.59
D_GND on IN2 (solid shape): 130.54,20.71 130.54,20.2 130.41,20.07 128.51,20.07 128.51,20.71 128.63,20.83 130.41,20.83
D_GND on IN2 (solid shape): 132.84,60.15 132.84,59.53 132.66,59.36 131.77,59.36 131.48,59.65 131.48,60.1 131.75,60.37 132.62,60.37
D_GND on IN2 (solid shape): 65.79,38.44 65.79,35.59 65.62,35.41 62.26,35.41 62.19,35.49 62.19,38.18 62.5,38.5 65.73,38.5
D_GND on IN2 (solid shape): 66.19,14.8 66.19,14.59 65.76,14.16 61.19,14.16 61.07,14.28 61.07,14.61 63.33,14.61 63.63,14.91 66.08,14.91
D_GND on IN2 (solid shape): 101.44,40.49 101.44,39.17 101.39,39.13 100.44,39.13 100.39,39.18 100.39,40.41 100.48,40.5 101.43,40.5
D_GND on IN2 (solid shape): 103.41,33.74 103.41,33.13 103.49,33.05 104.23,33.05 104.34,32.95 104.34,31.94 104.06,31.66 103.1,31.66 103.01,31.76 103.01,33.74 103.11,33.84 103.31,33.84
D_GND on IN2 (solid shape): 111.4,50.91 112.98,50.91 113.24,50.65 113.24,50.48 112.84,50.07 111.38,50.07 111.35,50.04 110.73,50.04 110.62,50.15 110.62,50.96 110.67,51.02 111.29,51.02
D_GND on IN2 (solid shape): 126.12,50.37 126.12,49.87 125.99,49.74 124.8,49.74 124.7,49.84 124.7,50.04 124.9,50.25 124.97,50.29 125.01,50.36 125.2,50.55 125.94,50.55
D_GND on IN2 (solid shape): 78.06,55.67 77.85,55.46 77.85,55.41 77.8,55.36 77.8,54.88 77.8,54.88 77.8,52.44 77.63,52.26 77.19,52.26 77.1,52.36 77.1,54.92 77.55,55.37 77.55,57.18 77.86,57.49 78.06,57.49
D_GND on IN2 (solid shape): 34.07,10.09 34.13,10.05 34.2,10.04 35.54,10.04 35.82,9.76 35.82,9.6 33.02,9.6 30.84,11.78 30.25,11.78 29.86,12.16 29.95,12.25 31.9,12.25
D_GND on IN2 (solid shape): 109.84,36.73 109.84,35.93 109.69,35.78 108.62,35.78 108.62,35.78 108.39,35.78 108.26,35.91 108.26,36.15 108.34,36.23 108.79,36.23 109.21,36.65 109.41,36.84 109.72,36.84
D_GND on IN2 (solid shape): 71.82,36.65 73.79,36.65 74.99,35.45 74.99,33.92 74.95,33.89 74.74,33.89 73.51,35.12 72.69,35.12 72.37,35.44 71.61,35.44 71.43,35.62 67.57,35.62 67.57,36.6 67.59,36.62 67.59,37.28 67.7,37.4 71.07,37.4
D_GND on IN2 (solid shape): 15.21,27.07 15.21,25.42 15.22,25.35 15.27,25.28 15.47,25.08 15.47,24.73 15.08,24.35 15.03,24.4 15.03,24.46 15.03,27.04 15.03,27.08 15.02,27.12 15,27.15 15.06,27.21
D_GND on IN2 (solid shape): 104.55,46.13 104.55,44.32 104.57,44.25 104.61,44.19 104.91,43.89 104.91,43.78 104.93,43.76 104.93,43.48 104.87,43.41 104.18,43.41 103.91,43.68 103.54,43.68 103.01,44.22 103.01,47.1 103.58,47.1
D_GND on IN2 (solid shape): 56.5,18.07 56.5,16.95 56.32,16.77 54.95,16.77 54.88,16.8 54.85,16.87 54.78,17.08 54.59,17.21 54.59,17.94 54.77,18.12 56.45,18.12
D_GND on IN2 (solid shape): 99.17,34.19 99.25,34.16 99.27,34.07 99.26,34.02 99.31,33.79 99.47,33.65 99.69,33.43 99.69,32.88 99.57,32.76 99.11,32.76 98.84,33.02 98.84,34.07 98.97,34.19
D_GND on IN2 (solid shape): 112.46,43.8 112.52,43.75 112.59,43.72 112.96,43.35 112.96,42.88 112.79,42.71 112.73,42.71 112.67,42.71 112.6,42.69 112.56,42.69 111.95,42.08 111.74,42.08 111.55,42.27 111.55,42.68 111.59,42.72 111.59,44 111.51,44.08 111.51,44.09 111.37,44.23 111.37,44.72 111.42,44.76 111.5,44.76
D_GND on IN2 (solid shape): 104.07,29.76 104.06,29.73 104.05,29.68 104.05,29.62 104.15,29.37 104.4,29.27 104.49,29.28 104.98,28.79 104.98,27.97 104.91,27.9 104.61,27.9 103.22,29.28 103.22,29.92 103.28,29.98 103.85,29.98
D_GND on IN2 (solid shape): 104.53,36.97 104.53,36.72 104.51,36.68 104.48,36.67 103.87,36.67 103.79,36.59 103.79,36.23 103.81,36.22 103.81,35.67 103.7,35.56 103.68,35.55 103.66,35.55 102.98,35.55 102.97,35.56 102.48,35.56 102.4,35.64 102.4,36.02 102.53,36.15 102.52,36.16 102.52,36.85 102.54,36.87 103.62,36.87 103.82,37.07 104.43,37.07
D_GND on IN2 (solid shape): 96.87,23.93 97,23.75 97.21,23.68 97.33,23.7 97.43,23.75 97.63,23.75 97.63,23.62 98.87,22.38 100.34,22.38 100.48,22.25 100.5,22.19 100.5,21.98 100.4,21.89 97.82,21.89 96.43,23.28 96.43,23.8 96.6,23.97 96.86,23.97
D_GND on IN2 (solid shape): 100.13,23.74 102.75,23.74 102.9,23.89 104.66,23.89 104.73,23.81 104.73,23.74 104.73,23.73 104.73,23.38 103.38,22.03 103.15,22.03 103,22.17 103.01,22.21 103.03,22.27 103.03,22.33 102.97,22.54 102.8,22.67 102.79,22.67 102.06,23.39 101.87,23.39 101.84,23.43 99.42,23.43 99.14,23.71 99.14,23.86 99.17,23.89 99.98,23.89
D_GND on IN2 (solid shape): 115.94,32.95 114.83,31.84 114.83,31.83 114.77,31.83 114.74,31.89 114.76,31.96 114.76,32.04 114.76,32.05 114.72,32.18 114.64,32.28 114.61,32.31 114.57,32.33 114.37,32.53 114.83,32.98 115.79,32.98 115.82,32.99 115.88,33
D_GND on IN2 (solid shape): 70.34,29.06 70.34,26.75 70.24,26.65 66.81,26.65 66.4,27.06 66.38,27.06 66.33,27.11 63.7,27.11 63.6,27.17 63.62,27.29 63.68,27.34 64.51,27.34 64.68,27.5 64.68,27.73 64.51,27.9 63.42,27.9 63.29,27.77 62.95,27.77 62.95,28.11 63.29,28.45 66.45,28.45 66.52,28.46 66.58,28.5 66.6,28.53 66.83,28.53 67.87,29.57 69.83,29.57
D_GND on IN2 (solid shape): 111.01,41.29 111.01,41.23 111.11,40.98 111.36,40.87 111.41,40.88 111.41,40.63 111.15,40.37 110.95,40.37 110.88,40.44 110.88,40.5 110.87,40.6 110.83,40.69 110.74,40.86 110.58,40.95 110.35,41.18 110.35,41.51 110.39,41.55 110.75,41.55
D_GND on IN2 (solid shape): 86.99,50.95 87.1,50.97 87.16,50.88 87.16,49.3 87.33,49.13 87.33,48.32 87.32,48.28 87.28,48.27 87.27,48.27 87.25,48.28 87.22,48.32 87.19,48.35 87.18,48.36 87.18,48.38 87.18,48.69 86.96,48.9 86.96,48.91 86.89,48.97 86.81,49 86.8,49 86.72,49.03 86.69,49.1 86.69,50.66
D_GND on IN2 (solid shape): 119.74,31.86 119.74,29.6 119.7,29.56 119.58,29.62 119.44,29.65 119.18,29.56 119.04,29.32 118.58,29.32 118.53,29.34 118.48,29.35 117.21,29.35 117.1,29.46 117.1,29.62 117.66,30.18 117.7,30.24 117.72,30.31 117.72,30.39 119.06,31.73 119.1,31.79 119.11,31.86 119.11,31.9 119.16,31.96 119.64,31.96
D_GND on IN2 (solid shape): 87.54,53.27 87.63,53.23 87.64,53.14 87.64,53.07 87.64,53.04 87.64,52.88 87.73,52.79 87.75,52.78 87.75,52.69 87.77,52.63 87.77,52.53 87.68,52.49 86.96,52.49 85.85,51.37 85.74,51.35 85.67,51.44 85.67,52.6 86.33,53.26 86.35,53.27 86.37,53.27
D_GND on IN2 (solid shape): 16.57,38.07 16.64,38.17 16.75,38.14 17.33,37.56 17.33,37.34 15.96,35.97 15.71,35.97 15.68,35.94 15.64,35.91 15.62,35.89 14.63,34.9 14.6,34.87 14.58,34.84 14.55,34.8 14.55,34.27 13.66,33.38 13.51,33.38 13.48,33.41 13.48,33.48 14.3,34.3 14.32,34.32 14.36,34.43 14.36,35.04 14.83,35.51 15.2,35.88 16.52,37.2 16.56,37.26 16.57,37.34
D_GND on IN2 (solid shape): 94.13,28.64 94.18,28.64 94.2,28.64 94.23,28.61 94.37,28.61 94.69,28.61 94.72,28.64 94.97,28.64 95.08,28.53 95.41,28.53 95.46,28.48 95.46,27.74 95.31,27.59 95.23,27.64 95.13,27.66 95.04,27.65 94.95,27.6 94.79,27.62 94.65,27.54 94.3,27.54 94.2,27.63 94.06,27.67 93.93,27.63 93.83,27.54 93.81,27.54 93.59,27.76 93.59,28.61 93.73,28.76 94.01,28.76
D_GND on IN2 (solid shape): 94.56,36.79 94.9,36.45 94.96,36.41 95.03,36.4 95.51,36.4 95.54,36.4 95.58,36.41 95.68,36.41 95.81,36.53 96.13,36.53 96.2,36.55 96.26,36.59 96.3,36.63 97.29,36.63 97.49,36.43 97.49,36.23 97.39,36.12 97.13,36.12 96.92,35.91 95.17,35.91 94.89,36.19 94.89,36.21 94.81,36.4 94.61,36.48 94.56,36.47 94.51,36.46 94.48,36.45 94.38,36.54 94.38,36.78 94.46,36.86 94.52,36.86
D_GND on IN2 (solid shape): 75.13,59.3 75.24,59.32 75.3,59.22 75.3,59.2 75.32,59.07 75.39,58.96 75.42,58.89 75.39,58.82 75.32,58.71 75.29,58.58 75.4,58.33 75.65,58.22 75.8,58.26 75.92,58.35 76.04,58.38 76.1,58.29 76.1,46.86 75.91,46.86 75.64,47.12 75.64,48.15 74.2,49.6 74.2,50.61 74.93,51.34 74.93,59.1
D_GND on IN2 (solid shape): 94.34,63.35 94.34,63.17 94.17,63 79.74,63 76.1,59.36 76.1,59.24 76.01,59.24 76,59.28 75.88,59.48 75.66,59.55 75.63,59.55 75.53,59.61 75.55,59.72 77.54,61.71 77.54,62.16 77.58,62.24 77.67,62.25 77.72,62.24 77.78,62.24 78.07,62.35 78.19,62.64 78.13,62.85 77.98,63 77.93,63.07 77.96,63.16 78.22,63.43 94.27,63.43
D_GND on IN2 (solid shape): 80.37,56.09 80.4,56.06 80.4,56.04 80.4,55.94 80.75,55.58 80.75,55.43 80.7,55.38 80.33,55.38 80.17,55.54 80.16,55.57 80.1,55.64 80,55.67 79.88,55.62 79.83,55.5 79.84,55.46 79.62,55.24 79.58,55.24 79.49,55.29 79.49,55.4 79.52,55.44 79.53,55.5 79.55,55.56 79.6,55.6 79.74,55.67 79.82,55.82 79.86,55.88 79.94,55.9 79.99,55.9 80.16,55.96 80.25,56.13 80.25,56.16 80.33,56.19
D_GND on IN2 (solid shape): 14.99,33.95 15.1,33.97 15.16,33.88 15.16,33.55 15.17,33.48 15.21,33.42 15.41,33.22 15.41,33 14.95,32.53 14.91,32.56 14.82,32.6 14.71,32.62 14.46,32.52 14.35,32.26 14.46,32.01 14.74,31.89 14.76,31.86 14.76,31.57 14.59,31.41 14.18,31 14.14,30.94 14.13,30.12 14.14,30.06 14.08,30.01 13.71,30.37 13.71,30.93 14.09,31.31 14.09,31.39 14.09,33.05
D_GND on IN2 (solid shape): 108.44,46.32 108.44,45.61 108.45,45.51 108.49,45.42 108.49,45.41 108.49,45.39 108.82,45.06 108.82,44.69 108.81,44.68 108.14,44.68 108.14,44.48 107.96,44.3 107.96,43.88 107.96,43.46 108.03,43.38 108.03,43.33 107.91,43.21 107.91,42.62 107.97,42.56 107.92,42.51 107.9,42.51 107.71,42.45 107.58,42.29 107.52,42.23 107.45,42.23 107.38,42.3 107.41,42.4 107.53,42.51 107.53,43.48 107.34,43.67 107.31,43.67 107.29,43.7 107.25,43.74 107.25,43.81 107.3,43.86 107.3,45.22 107.26,45.26 107.26,45.36 106.59,45.36 106.49,45.37 106.38,45.36 106.2,45.36 106.2,45.5 105.55,45.5 105.55,46.19 105.77,46.42 108.34,46.42
D_GND on IN2 (solid shape): 65.01,42.68 65.01,42.5 65.13,42.37 65.29,42.37 65.41,42.25 65.41,42.2 65.31,42.09 65.08,42.09 65.01,42.02 65.01,41.46 65.57,40.9 65.57,40.6 65.26,40.29 62.85,40.29 62.85,40.96 62.9,41.05 63,41.05 63.09,41.01 63.18,41 63.29,41.02 63.39,41.07 63.45,41.09 63.51,41.06 63.6,41.01 63.7,40.99 63.9,41.07 63.98,41.27 63.96,41.37 63.9,41.46 63.88,41.57 63.97,41.64 64.45,41.64 64.7,41.89 64.7,42.07 64.74,42.11 64.74,42.34 64.7,42.38 64.7,42.49 64.71,42.5 64.73,42.57 64.74,42.65 64.76,42.72 64.84,42.75 64.93,42.75
