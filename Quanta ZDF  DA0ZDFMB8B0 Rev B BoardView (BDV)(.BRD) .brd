# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PPVAR_SYS_BL_P: length 32.8
  TOP w0.076: R442.1 35.97,29.36 35.97,29.99 39.8,33.81 45.27,33.81 46.09,34.64 50.57,34.64 51.75,35.82 56,35.82 57.54,37.36 57.54,40.37 57.49,40.42 v6(57.23,40.42)
  BOTTOM w0.076: NC303.2 58.84,38.69 58.69,38.84 58.56,38.84 58.38,39.02 58.38,39.82 57.55,40.65 57.46,40.65 v6(57.23,40.42)
PPVAR_SYS_N: length 24.5
  TOP w0.076: v2(103.25,15.26) 103.39,15.12 103.53,15.12 103.84,14.8 103.84,13.72 105.85,11.72 112.26,11.72 114.37,9.61 116.73,9.61 118.17,11.04 118.17,11.31 118.75,11.89 118.92,11.89 119,11.97 119,12.12 119.07,12.2 R90500.1
  IN2 w0.076: v3(104.5,17.66) 104.5,17.24 104.43,17.16 104.01,17.16 103.84,17 103.84,15.31 103.65,15.12 103.39,15.12 v2(103.25,15.26)
  IN4 w0.076: v5(104.93,17.66) v3(104.5,17.66)
PPVAR_SYS_P: length 24.5
  TOP w0.076: R90501.1 119.07,11.44 119,11.51 119,11.66 118.92,11.74 118.81,11.74 118.32,11.25 118.32,10.98 116.8,9.45 114.31,9.45 112.2,11.56 105.79,11.56 103.69,13.66 103.69,14.74 103.46,14.97 103.38,14.97 v2(103.24,14.83)
  IN2 w0.076: v3(104.5,16.52) 104.5,16.94 104.43,17.01 104.07,17.01 104,16.93 104,15.25 103.71,14.96 103.38,14.96 v2(103.24,14.83)
  IN4 w0.076: v5(104.93,16.52) v3(104.5,16.52)
PPVAR_SYS_R: length 1.5
  BOTTOM w0.089: R90840.1 102.31,15.64 102.31,15 102.4,14.92 R612.1
  vias: v6(105.34,16.06) v6(105.67,16.69) v6(105.7,15.42) v6(106.05,16.06) v6(106.38,16.69) v6(106.43,15.45) v6(106.76,16.08) v6(107.15,15.47) v6(107.48,16.11) v6(107.93,15.5) v6(119.13,23.37) v6(119.13,22.66) v6(119.16,25.51) v6(119.16,24.8) v6(119.16,24.09) v6(119.85,23.37) v6(119.85,22.66) v6(119.9,25.51) v6(119.9,24.8) v6(119.9,24.09)
PPVAR_USB_C0_VBUS: length 170.9
  TOP w0.203: v2(132.01,43.21) 126.86,43.21 125.24,41.6 123.92,41.6 123.4,41.07 123.4,40.43 R503.1 124.23,40.27 124.49,40.01 v1(124.49,39.45)
  TOP w0.254: U6533.A2 25.64,43.72 25.84,43.52 26.73,43.52 26.98,43.77
  IN1 w0.203: v2(126.98,57.33) 126.83,57.49 126.83,58.96 126.73,59.06 126.73,62.03 127.87,63.18 127.87,65.69 v2(127.8,65.77) ; v1(132.3,34.88) 131.81,34.88 131.37,35.32 131.37,36.09 130.56,36.89 124.7,36.89 124.37,37.22 124.37,37.62 124.09,37.9 124.09,39.05 v1(124.49,39.45)
  IN2 w0.203: v2(126.98,57.33) 127.24,57.59 129.32,57.59 130.52,56.39 130.52,55.5 131.51,54.51 131.51,53.68 132.19,53 132.19,49.81 132.53,49.47 132.53,45.91 132.19,45.57 132.19,43.39 v2(132.01,43.21) ; v2(127.8,65.77) 127.36,66.2 126.45,66.2 126.02,65.77 123.48,65.77 123.33,65.61 121.47,65.61 120.87,65.01 118.75,65.01 117.59,66.17 76.99,66.17 74.58,63.76 74.58,62.7 71.36,59.48 v3(71.36,58.12)
  IN4 w0.203: v5(68.31,50.55) 67.86,51 65.04,51 64.09,50.04 63.33,50.04 61.14,47.86 59.44,47.86 58.23,46.64 56.88,46.64 55.66,47.86 43.17,47.86 41.42,46.11 36.43,46.11 36.18,45.85 28.68,45.85 28.35,45.52 28.35,43.39 v6(28.43,43.31) ; v5(71.69,57.87) 71.61,57.87 v3(71.36,58.12)
  BOTTOM w0.203: v5(71.69,57.87) 71.5,57.68 71.5,52.99 70.06,51.55 70.06,51.06 69.84,50.84 69.01,50.84 68.72,50.55 v5(68.31,50.55)
  vias: v6(23.48,46.36) v6(23.81,47) v6(24.32,46.13) v6(25.1,46.11) v6(25.56,47.38) v6(25.56,46.67) v6(27.72,43.32) v6(27.75,42.6) v6(28.51,42.58)
PPVAR_USB_C0_VBUS_N: length 34.6
  IN2 w0.076: v2(13.06,21.62) 12.76,21.92 12.76,22.38 14.84,24.46 14.84,27.04 14.59,27.3 14.59,28.21 14.08,28.72 14.08,28.87 12.84,30.12 12.84,31.18 13.29,31.64 13.29,33.56 14.17,34.43 14.17,35.12 16.38,37.34 16.38,37.72 16.08,38.02 16.08,41.83 15.84,42.08 15.84,45.46 16.81,46.44 19,46.44 19.86,45.57 21.36,45.57 21.62,45.83 21.62,45.95 21.73,46.06 v2(22.08,46.06)
PPVAR_USB_C0_VBUS_P: length 34.6
  IN2 w0.076: v2(12.3,21.62) 12.61,21.92 12.61,22.44 14.69,24.52 14.69,26.98 14.44,27.23 14.44,28.14 13.93,28.65 13.93,28.81 12.68,30.05 12.68,31.25 13.14,31.71 13.14,33.62 14.01,34.5 14.01,35.18 16.23,37.4 16.23,37.66 15.93,37.96 15.93,41.77 15.68,42.01 15.68,45.52 16.75,46.59 19.06,46.59 19.93,45.72 21.3,45.72 21.47,45.89 21.47,45.98 21.4,46.06 v2(21.06,46.06)
PPVAR_USB_C0_VBUS_R: length 151.3
  TOP w0.203: U6.16 127.16,33.79 127.43,34.05 v6(127.43,34.4)
  IN2 w0.508: v3(31.76,40.21) 30.74,39.19 v6(30.74,38.08)
  IN3 w0.508: v3(31.76,40.21) 32.95,40.21 36.66,43.92 41.08,43.92 41.79,43.21 47.81,43.21 48.19,43.59 53.83,43.59 54.49,42.93 v3(54.87,42.93)
  IN4 w0.508: v3(54.87,42.93) 56.02,42.93 56.55,43.47 56.55,44.35 57.98,45.78 58.61,45.78 59.83,47 61.5,47 63.46,48.95 64.98,48.95 65.08,48.85 66.61,48.85 67.55,49.79 68.39,49.79 68.54,49.94 69.73,49.94 70.16,50.37 70.16,59.29 70.9,60.03 v5(72.58,60.03) 73.03,60.49 v5(73.03,60.51)
  BOTTOM w0.508: v6(127.43,34.4) 117.2,34.4 116.52,35.08 116.52,40.14 114.99,41.66 114.99,45.04 115.58,45.62 117.43,45.62 118.96,47.15 118.96,50.59 121.99,53.61 121.99,55.2 120.82,56.37 114.84,56.37 106.93,64.28 76.81,64.28 v5(73.03,60.51) 73.03,60.49 v5(72.58,60.03)
PPVAR_VSYS_R: length 1.6
  BOTTOM w0.089: R90841.1 102.07,15.61 102.07,14.99 101.99,14.92 R612.2
PROTO_SEL: length 3.6
  TOP w0.089: R90860.1 150.65,41.44 U6575.A1
PWRAP_SPI0_CK: length 30.4
  IN2 w0.058: v8(89.44,38.76) 89.44,38.86 89.69,39.12 89.69,39.25 89.95,39.5 93.4,39.5 93.51,39.4 94.45,39.4 94.84,39.8 95.69,39.8 96.53,40.64 96.53,40.7 96.8,40.97 96.8,41.03 97.1,41.33 97.1,42.46 97.49,42.86 97.49,43.36 97.88,43.74 97.88,44.18 98.49,44.8 98.49,45.56 99.01,46.08 99.01,46.41 100.94,48.34 103.2,48.34 105.16,46.38 105.16,44.5 105.54,44.11 105.54,43.04 106.44,42.13 106.44,41.81 106.51,41.74 106.51,41.31 106.32,41.12 106.19,41.12 105.82,40.75 105.82,39.85 v8(106.02,39.65)
PWRAP_SPI0_CSN: length 22.7
  TOP w0.089: R1001.1 R1004.2 95.48,40.31 v2(95.66,40.49)
  IN1 w0.06: v2(104.96,39.54) 105.19,39.54 105.5,39.85 105.76,39.85 105.82,39.92 105.82,40.25 106.02,40.45 v7(106.02,40.45)
  IN2 w0.058: v3(103.64,39.26) 103.64,39.99 103.69,40.04 103.84,40.04 103.89,39.99 103.89,39.59 103.94,39.54 104.1,39.54 104.15,39.59 104.15,39.99 104.2,40.04 104.3,40.04 104.35,39.99 104.35,39.69 104.5,39.54 v2(104.96,39.54) ; v3(96.02,40.69) 95.82,40.49 v2(95.66,40.49) 95.18,40.01 94.75,40.01 94.37,39.63 89.91,39.63 v8(89.44,39.16)
  IN3 w0.102: v3(96.02,40.69) 96.02,40.14 97.69,38.47 102.42,38.47 103.21,39.26 v3(103.64,39.26)
PWRAP_SPI0_MI: length 31.9
  IN1 w0.06: 90.76,39.21 90.57,39.21 90.32,38.96 90.03,38.96 v7(89.83,38.76) ; 106.62,39.9 106.62,39.51 106.42,39.31 v7(106.42,39.25)
  IN1 w0.076: v2(95.28,37.93) 94.67,37.93 93.3,39.3 90.85,39.3 90.76,39.21 ; 106.62,39.9 106.69,39.97 106.69,40.14 106.56,40.27 106.56,41.11 106.51,41.16 106.51,41.44 106.26,41.69 v2(106.23,41.69)
  IN2 w0.058: v2(106.23,41.69) 106.23,42.05 105.33,42.95 105.33,44.03 104.95,44.41 104.95,46.29 103.11,48.13 101.03,48.13 99.22,46.32 99.22,45.99 98.7,45.47 98.7,44.71 98.09,44.1 98.09,43.64 97.72,43.28 97.72,42.79 97.31,42.38 97.31,40.59 97.61,40.29 97.61,39.73 95.96,38.08 95.44,38.08 v2(95.28,37.93)
PWRAP_SPI0_MO: length 30.9
  IN1 w0.06: v7(106.42,39.65) 106.22,39.85 106.22,40.22 106.41,40.4 ; 90.76,39.07 90.6,39.07 90.32,38.79 90.26,38.79 v7(90.24,38.76) ; 93.19,39.17 93.99,38.37
  IN1 w0.075: 93.19,39.17 90.93,39.17 90.84,39.07 90.76,39.07
  IN1 w0.076: v2(106.22,41.34) 106.22,41.19 106.41,41.01 106.41,40.4 ; v2(95.28,37.53) 95.05,37.75 94.61,37.75 93.99,38.37
  IN2 w0.058: v2(106.22,41.34) 106.22,41.34 105.97,41.59 105.97,42 105.12,42.86 105.12,43.94 104.73,44.32 104.73,46.21 103.02,47.92 101.12,47.92 99.43,46.23 99.43,45.9 98.91,45.39 98.91,44.62 98.3,44.01 98.3,43.54 97.95,43.19 97.95,42.72 97.62,42.39 97.62,41.71 97.54,41.62 97.54,40.66 97.82,40.38 97.82,39.64 96.03,37.85 95.67,37.85 95.34,37.53 v2(95.28,37.53)
PWRKEY: length 6.1
  TOP w0.089: v2(104.81,36) 104.85,36.05 U2001.D2 ; v2(104.49,31.39) 104.49,31.48 104.78,31.77 104.94,31.77 R90606.1
  IN2 w0.058: v2(104.81,36) 104.81,35.98 104.73,35.9 104.73,35.44 104.73,35.44 104.73,31.62 v2(104.49,31.39)
RAM_ID: length 12.5
  TOP w0.089: v2(86.07,25.3) 86.16,25.21 R90727.1
  IN2 w0.058: v2(86.07,25.3) 86.21,25.44 86.21,27.25 86.92,27.97 86.92,29.36 87.27,29.71 87.27,30.01 88.3,31.05 88.3,33.71 87.86,34.15 87.77,34.15 87.66,34.25 87.66,34.26 v8(87.5,34.42) 87.82,34.75 v3(87.82,34.75)
  IN4 w0.058: v5(87.74,34.33) 87.84,34.43 87.84,34.73 v3(87.82,34.75)
REFP: length 2.4
  TOP w0.089: C1009.2 85.91,32.18 86.21,32.49 86.71,32.49 86.98,32.76 U1001.AJ18
RING2: length 3.5
  TOP w0.254: v1(12.76,33.03) 12.76,33.79 13.25,34.28 R90334.1
  IN1 w0.254: v1(11.84,32.21) 12.05,32.42 12.05,32.57 12.51,33.03 v1(12.76,33.03)
RING2_SENSE: length 6.3
  TOP w0.254: v1(9.26,28.2) 9.26,28.08 8.8,27.62 7.78,27.62 7.23,27.07 R90765.1
  IN1 w0.254: v1(9.26,28.2) 9.26,28.72 10.32,29.78 v1(11.5,29.78)
RTC32K_CK: length 18.7
  TOP w0.075: 92.01,40.6 91.53,40.12 90.87,40.12 U1001.K26
  TOP w0.089: 92.01,40.6 92.17,40.76 93.32,40.76 93.71,40.37 93.71,40.04 94.06,39.68 94.06,39.58 94.2,39.44 94.97,39.44 v2(95.46,38.94)
  IN2 w0.058: v2(95.46,38.94) 96.27,38.94 v3(97.14,39.81) ; v3(106.33,39.38) 106.15,39.38 v8(106.02,39.25)
  IN3 w0.102: v3(97.14,39.81) 98.22,38.72 102.32,38.72 103.18,39.58 104.38,39.58 104.5,39.45 106.26,39.45 v3(106.33,39.38)
SCP_VREQ_VAO: length 44
  IN1 w0.06: 90.67,39.36 90.54,39.36 90.36,39.18 90.26,39.18 v7(90.24,39.16)
  IN1 w0.076: v2(107.76,28.81) 107.96,28.61 107.96,27.49 107.27,26.8 105.82,26.8 105.39,26.37 99.98,26.37 95.64,30.7 95.64,32.67 94.74,33.57 94.74,34.61 94.45,34.91 94.45,35.92 94.27,36.1 94.27,37.06 94.5,37.29 95.41,37.29 95.51,37.39 95.51,38.06 95.41,38.16 94.65,38.16 93.37,39.44 90.75,39.44 90.67,39.36
  IN2 w0.058: v2(107.76,28.81) 107.76,29.37 106.89,30.23 106.7,30.23 106.48,30.45 106.48,30.69 106.52,30.73 106.52,32.23 106.63,32.34 106.63,33.75 106.34,34.03 106.34,35.24 106.46,35.36 106.46,35.65 106.23,35.88 106.23,36.33 106.44,36.55 106.44,37.03 106.23,37.24 106.23,37.85 106.64,38.26 106.64,39.22 106.69,39.27 106.69,39.5 106.61,39.58 106.61,39.84 106.64,39.87 106.64,40.24 v8(106.84,40.44)
SDIO_INT_ODL: length 92.9
  TOP w0.089: v1(79.42,42.2) 79.42,42.08 R90625.1
  IN1 w0.06: v7(81.83,40.76) 81.82,40.78 81.19,40.78 80.91,41.06
  IN1 w0.076: 80.91,41.06 80.81,41.06 80.58,41.28 80.41,41.28 79.5,42.2 v1(79.42,42.2) 78.24,42.2 77.15,43.29 75.43,43.29 73.01,45.71 73.01,50.16 73.11,50.26 v2(73.11,50.55)
  IN2 w0.058: v3(131.3,60.97) 131.3,61.22 130.13,62.39 128.86,62.39 128.25,63 125.26,63 124.33,62.07 122.66,62.07 122.39,62.34 120.68,62.34 120,63.02 117.8,63.02 116.62,64.2 77.86,64.2 76.73,63.07 76.73,62.07 74.13,59.46 74.13,52.2 73.04,51.11 73.04,50.61 73.1,50.55 v2(73.11,50.55)
  IN4 w0.058: v3(131.3,60.97) 131.3,60.84 v5(131.55,60.59)
  BOTTOM w0.089: v5(131.55,60.59) 134.42,57.72 U1007.46
SERVO_EC_BOOT0_ODL: length 5.1
  TOP w0.089: Q8.1 38.91,6.94 v2(39.23,6.63)
  IN2 w0.058: v2(39.23,6.63) 38.99,6.63 38.59,6.23 38.59,5.72 v3(38.72,5.59)
  IN4 w0.058: v5(39.35,5.11) 39.2,5.11 v3(38.72,5.59)
  BOTTOM w0.089: v5(39.35,5.11) 39.7,4.76 CON16.41
SERVO_JTCK: length 70
  TOP w0.089: R90340.2 93.79,26.04 94.06,26.04 94.09,26.02 v2(94.24,26.02) ; v2(44.69,5.7) 44.69,5.82 44.96,6.09 R313.2 45.19,4.97 R90962.2 45.48,4.71 46.38,3.82 48.24,3.82 48.95,4.53 v2(50.27,4.53)
  IN2 w0.058: v2(44.69,5.7) 44.41,5.7 v3(44.31,5.59) ; v2(50.27,4.53) 50.86,4.53 52.84,6.5 52.84,7.5 53.65,8.31 53.65,9.76 54.06,10.17 57.93,10.17 58.39,10.63 60.62,10.63 60.79,10.8 61.91,10.8 62.27,10.44 72.92,10.44 73.78,11.3 74.83,11.3 77.65,14.12 79.13,14.12 79.66,14.66 82.73,14.66 83.59,15.52 84.5,15.52 85.47,16.49 88.03,16.49 88.94,17.39 89.69,17.39 93.67,21.37 93.96,21.37 94.9,22.31 94.9,24.3 94.58,24.63 94.58,24.79 94.09,25.28 94.09,25.96 94.15,26.02 v2(94.24,26.02)
  IN4 w0.058: v5(43.7,4.8) 43.82,4.8 44.31,5.29 v3(44.31,5.59)
  BOTTOM w0.089: CON16.21 v5(43.7,4.8)
SERVO_JTDI: length 70
  TOP w0.089: R90342.2 90.53,30.47 90.62,30.38 90.91,30.38 91.04,30.26 91.04,27.82 91.27,27.59 91.8,27.59 92.19,27.21 92.19,25.9 92.3,25.79 93.2,25.79 v2(93.3,25.69)
  IN2 w0.058: v2(93.3,25.69) 93.3,25.17 93.95,24.53 93.95,24.37 94.27,24.04 94.27,22.57 93.7,22 93.4,22 89.43,18.03 88.68,18.03 87.77,17.12 85.2,17.12 84.24,16.15 83.33,16.15 82.47,15.29 79.38,15.29 78.85,14.76 77.39,14.76 74.57,11.94 73.51,11.94 72.65,11.08 62.53,11.08 62.18,11.43 60.5,11.43 60.34,11.26 58.13,11.26 57.67,10.8 53.79,10.8 52.97,9.98 52.97,8.82 v3(52.01,7.86)
  IN4 w0.058: v5(51.39,7.86) v3(52.01,7.86)
  BOTTOM w0.089: CON16.24 43.3,7.49 43.57,7.22 48.68,7.22 49.6,8.13 51.12,8.13 v5(51.39,7.86)
SERVO_JTDO: length 73.9
  TOP w0.089: R90343.2 92.03,28.86 92.08,28.81 92.08,28.25 92.85,27.49 93.2,27.49 93.53,27.16 93.53,27.06 v2(93.89,26.7) ; v2(48.93,3.79) 48.93,3.71 48.65,3.44 45.03,3.44 44.94,3.52 44.94,4.21 R90963.2 44.43,5.34 44.18,5.59 v2(44.18,6.09)
  IN2 w0.058: v2(48.93,3.79) 48.95,3.82 49.39,3.82 49.92,4.35 49.92,4.93 50.48,5.49 51.22,5.49 52.41,6.69 52.41,7.68 53.2,8.46 53.2,9.91 53.88,10.59 57.75,10.59 58.21,11.05 60.43,11.05 60.6,11.22 62.09,11.22 62.44,10.87 72.74,10.87 73.6,11.73 74.66,11.73 77.47,14.55 78.96,14.55 79.49,15.08 82.56,15.08 83.42,15.94 84.33,15.94 85.29,16.91 87.86,16.91 88.77,17.82 89.52,17.82 93.49,21.79 93.79,21.79 94.48,22.48 94.48,24.13 94.16,24.45 94.16,24.62 93.63,25.14 93.63,26.4 93.89,26.65 v2(93.89,26.7) ; v2(44.18,6.09) 43.97,5.89 43.89,5.89 v3(43.8,5.98)
  IN4 w0.058: v5(43.67,5.47) 43.67,5.72 43.8,5.85 v3(43.8,5.98)
  BOTTOM w0.089: CON16.25 42.9,4.7 v5(43.67,5.47)
SERVO_JTMS: length 70.4
  TOP w0.089: v2(94.06,27.39) 93.89,27.39 93.38,27.9 93.02,27.9 92.74,28.17 R90341.2
  IN2 w0.058: v3(50.66,5.09) 51.12,5.09 52.63,6.59 52.63,7.59 53.42,8.39 53.42,9.84 53.97,10.38 57.84,10.38 58.3,10.84 60.52,10.84 60.69,11.01 62,11.01 62.35,10.66 72.83,10.66 73.69,11.51 74.74,11.51 77.56,14.33 79.04,14.33 79.58,14.87 82.64,14.87 83.51,15.73 84.41,15.73 85.38,16.7 87.95,16.7 88.85,17.61 89.6,17.61 93.58,21.58 93.88,21.58 94.69,22.39 94.69,24.22 94.37,24.54 94.37,24.7 93.84,25.23 93.84,26.15 94.21,26.52 94.21,27.24 v2(94.06,27.39)
  IN4 w0.058: v5(50.27,4.96) 50.27,5.03 50.33,5.09 v3(50.66,5.09)
  BOTTOM w0.089: CON16.23 43.3,2.79 43.67,2.42 47.91,2.42 49.77,4.27 49.77,4.45 v5(50.27,4.96)
SERVO_JTRST: length 89.6
  TOP w0.089: R90591.2 87.1,28.08 87.09,28.07 v2(86.57,28.07)
  IN2 w0.058: v2(86.57,28.07) 86,27.5 86,25.73 85.27,25 83.5,25 83.14,24.64 80.14,24.64 76.78,28.01 75.91,28.01 74.03,29.89 74.03,31.15 72.36,32.82 70.93,32.82 70.13,33.61 67.67,33.61 67.08,33.03 66.44,33.03 65.81,32.41 64.28,32.41 62.74,33.94 60.93,33.94 59.83,35.05 59.83,35.13 v3(59.8,35.16) ; v3(56.85,12.2) 56.85,12.17 56.7,12.02 53.04,12.02 51.19,10.18 51.19,8.66 50.8,8.28 50.8,7.93 v3(50.63,7.75)
  IN4 w0.058: v3(56.85,12.2) 56.85,12.55 v4(56.83,12.58) ; v4(59.09,34.91) 59.34,35.16 v3(59.8,35.16) ; v3(50.63,7.75) 50.58,7.7 50.58,7.6 50.45,7.47 v5(50.45,7.45)
  IN5 w0.076: v4(56.83,12.58) 56.83,13.31 55.31,14.84 55.31,16.11 54.4,17.02 53.03,17.02 52.48,17.57 52.48,18.56 51.86,19.18 51.86,19.43 51.41,19.88 51.41,21.11 51.41,25.11 53.28,26.98 58.19,26.98 60,28.79 60,33.99 v4(59.09,34.91)
  BOTTOM w0.089: v5(50.45,7.45) 50.45,7.44 50.36,7.35 49.5,7.35 48.88,6.73 44.4,6.73 42.5,4.83 CON16.27
SERVO_SYS_RST_ODL: length 3.5
  IN2 w0.058: v2(41.1,6.61) 41.1,6.25 v3(40.95,6.1)
  IN4 w0.058: v5(40.98,5.72) 40.98,6.08 v3(40.95,6.1)
  BOTTOM w0.089: v5(40.98,5.72) 40.88,5.72 40.1,4.94 CON16.39
SLEEVE: length 4.1
  IN1 w0.254: v1(7.35,31.38) 7.86,31.88 10.14,31.88 10.36,31.67 v1(11.16,31.67)
SLEEVE_SENSE: length 5.1
  TOP w0.254: R91140.1 7.31,30.15 7.63,29.83 8.77,29.83 v1(9.25,29.34)
  IN1 w0.254: v1(9.25,29.34) 10.23,30.32 v1(11.5,30.32)
SOC_I2C0_1V8_SCL: length 63.3
  TOP w0.089: Q777.4 46.33,48.38 46.13,48.58 45,48.58 44.61,48.19 v1(44.61,48.08)
  IN1 w0.076: v2(41.41,42.92) 41.28,43.05 41.28,43.65 43.46,45.82 43.46,47.55 43.64,47.73 44.26,47.73 v1(44.61,48.08)
  IN2 w0.058: v8(82.63,35.57) 82.14,35.57 81.74,35.96 80.59,35.96 80.3,36.25 80.04,36.25 79.54,36.76 79.1,36.76 78.01,37.85 77.28,37.85 v2(76.97,38.16) 76.97,37.93 76.87,37.84 76.7,37.84 76.64,37.9 76.64,38.64 75.93,39.36 75.93,40.3 74.12,42.12 74.12,46.18 72.97,47.33 71.71,47.33 71.34,47.7 68.04,47.7 67.24,46.89 67.24,46.04 65.82,44.62 63.81,44.62 62.99,45.45 61.36,45.45 60.51,44.6 57.19,44.6 56.03,43.44 46.76,43.44 45.92,42.59 41.32,42.59 41.25,42.66 41.25,42.76 v2(41.41,42.92)
SOC_I2C0_1V8_SDA: length 64.2
  TOP w0.089: Q776.4 42.05,47.07 41.76,47.36 41.76,48.43 41.89,48.56 43.58,48.56 43.77,48.37 v1(43.77,48.08)
  IN1 w0.076: v1(43.77,48.08) 43.53,47.84 43.3,47.62 43.3,45.89 41.13,43.71 41.13,43.08 v2(40.98,42.93)
  IN2 w0.058: v2(40.98,42.93) 41.14,42.77 41.14,42.61 41.27,42.47 45.96,42.47 46.81,43.32 56.07,43.32 57.24,44.48 60.56,44.48 61.41,45.33 62.94,45.33 63.76,44.51 65.87,44.51 67.36,46 67.36,46.85 68.09,47.58 71.29,47.58 71.66,47.21 72.92,47.21 74,46.13 74,42.07 75.8,40.27 75.8,39.32 76.53,38.6 76.53,37.78 76.58,37.73 76.82,37.73 76.97,37.58 v2(76.97,37.4) 77.3,37.74 77.96,37.74 79.06,36.64 79.49,36.64 80,36.14 80.25,36.14 80.54,35.85 81.69,35.85 82.13,35.41 82.13,35.29 82.23,35.19 v8(82.23,35.19)
SOC_I2C2_1V8_SCL: length 99.6
  TOP w0.075: U1001.AB2 80.76,35.29 80.35,35.29 80.3,35.34
  TOP w0.089: 80.3,35.34 79.99,35.34 79.81,35.16 79.26,35.16 78.9,34.8 78.86,34.8 R1106.2
  IN2 w0.058: v3(34.96,32.01) 35.38,31.59 35.98,31.59 36.7,32.31 36.99,32.31 37.58,32.9 38.93,32.9 40.06,34.03 41.9,34.03 42.13,34.26 42.97,34.26 43.46,34.74 43.46,35 44.3,35.85 52.28,35.85 53.97,37.54 55.45,37.54 56.15,38.24 57.91,38.24 57.99,38.33 61.19,38.33 62.17,39.31 67.96,39.31 68.42,38.84 73.67,38.84 76.55,35.96 77.02,35.96 78.17,34.81 78.46,34.81 78.52,34.76 v2(78.52,34.48) ; v3(57.44,12.4) 57.26,12.22 57.26,12.04 57.04,11.81 53.12,11.81 51.4,10.09 51.4,8.58 51.02,8.19 51.02,7.27 v2(50.99,7.25)
  IN4 w0.058: v5(57.26,12.73) 57.26,12.58 57.44,12.4 v3(57.44,12.4) ; v3(34.96,32.01) 35.39,31.58 35.39,30.85 35.34,30.8 35.12,30.8 35.03,30.89 v5(35.03,30.92)
  BOTTOM w0.089: v5(57.26,12.73) 57.26,12.71 57.12,12.57 57.02,12.57 56.93,12.66 56.93,13.34 56.17,14.1 55.86,14.1 55.35,14.61 55.35,20.45 53.91,21.9 52.33,21.9 51.96,22.27 50.68,22.27 49.85,23.09 41.94,23.09 39.71,25.33 39,25.33 37.12,27.21 37.12,29.49 35.95,30.66 35.37,30.66 35.11,30.92 v5(35.03,30.92)
SOC_I2C2_1V8_SDA: length 101.9
  TOP w0.075: 80.32,35.49 80.36,35.49 80.36,35.48 80.56,35.48 U1001.AB1 ; 80.3,35.49 80.31,35.49
  TOP w0.089: Q767.2 50.86,5.75 50.4,6.2 v2(50.4,6.36) ; 80.3,35.49 79.89,35.49 79.74,35.34 79.18,35.34 78.83,34.98 78.75,34.98 R1105.2 ; 80.31,35.49 80.32,35.49
  IN2 w0.058: v3(58.05,12.33) 57.92,12.33 57.59,11.99 57.38,11.99 57.08,11.69 53.17,11.69 51.52,10.04 51.52,8.53 51.13,8.14 51.13,7.58 51.32,7.4 51.32,6.62 51.06,6.36 v2(50.4,6.36) ; v3(35.57,31.98) 35.85,31.71 35.94,31.71 36.66,32.42 36.94,32.42 37.53,33.02 38.89,33.02 40.01,34.14 41.85,34.14 42.08,34.37 42.92,34.37 43.34,34.79 43.34,35.05 44.26,35.96 52.23,35.96 53.93,37.66 55.4,37.66 56.11,38.36 57.86,38.36 57.95,38.45 61.14,38.45 62.12,39.43 68,39.43 68.47,38.96 73.72,38.96 76.6,36.07 77.07,36.07 78.21,34.93 78.46,34.93 78.52,34.99 v2(78.52,35.19)
  IN4 w0.058: v5(35.09,30.49) 35.09,30.5 35.27,30.69 35.39,30.69 35.51,30.8 35.51,31.63 35.46,31.68 35.46,31.87 v3(35.57,31.98) ; v5(57.87,12.66) 58.05,12.48 v3(58.05,12.33)
  BOTTOM w0.089: v5(35.09,30.49) 35.87,30.49 36.94,29.42 36.94,27.14 38.92,25.15 39.63,25.15 41.87,22.92 49.78,22.92 50.61,22.09 51.89,22.09 52.26,21.72 53.83,21.72 55.18,20.38 55.18,14.54 55.79,13.93 56.09,13.93 56.75,13.27 56.75,12.58 56.94,12.39 57.38,12.39 57.64,12.66 v5(57.87,12.66)
SOC_I2C3_1V8_SCL: length 87.4
  IN1 w0.06: v7(89.03,33.96) 89.03,33.84 88.83,33.64 88.83,33.41 88.72,33.29 88.72,30.3 88.65,30.24
  IN1 w0.076: 88.65,30.24 88.5,30.09 88.5,27.88 88.29,27.67 88.29,27.46 88.21,27.38 v2(87.99,27.38)
  IN2 w0.058: v2(87.99,27.38) 88.22,27.38 88.28,27.33 88.28,27.16 88.18,27.06 87.6,27.06 87.34,26.8 87.34,24.5 86.64,23.8 85.54,23.8 85.25,24.09 83.82,24.09 83.4,23.67 79.7,23.67 76.38,26.99 75.73,26.99 73.18,29.55 73.18,30.75 71.95,31.97 69.74,31.97 69.16,32.56 68.11,32.56 67.52,31.97 66.87,31.97 66.25,31.35 63.84,31.35 62.32,32.87 60.17,32.87 59.61,33.43 53.23,33.43 52.18,32.38 48.42,32.38 47.86,32.94 46.95,32.94 46.9,32.89 45.18,32.89 44.29,32 43.05,32 42.66,31.6 40.46,31.6 39.96,31.11 39.09,31.11 29.98,22 29.98,20.21 29.71,19.95 29.25,19.95 v3(29.03,20.17)
  IN4 w0.058: v5(28.63,20.07) 28.94,20.07 v3(29.03,20.17)
  BOTTOM w0.089: R90783.1 25.53,19.51 25.59,19.58 25.59,19.65 25.84,19.89 28.46,19.89 v5(28.63,20.07)
SOC_I2C3_1V8_SDA: length 86.9
  IN1 w0.06: v7(89.03,33.56) 89.03,33.44 88.83,33.24 88.83,30.21
  IN1 w0.076: v2(88.68,27.38) 88.56,27.38 88.44,27.5 88.44,27.61 88.65,27.82 88.65,30.03 88.83,30.21
  IN2 w0.058: v3(29.06,19.56) 29.33,19.83 29.76,19.83 30.1,20.16 30.1,21.95 39.14,30.99 40.01,30.99 40.5,31.49 42.71,31.49 43.1,31.88 44.34,31.88 45.23,32.77 46.95,32.77 47,32.82 47.81,32.82 48.37,32.26 52.23,32.26 53.28,33.32 59.56,33.32 60.12,32.76 62.27,32.76 63.79,31.23 66.3,31.23 66.92,31.86 67.57,31.86 68.16,32.44 69.11,32.44 69.69,31.86 71.91,31.86 73.06,30.71 73.06,29.5 75.69,26.87 76.33,26.87 79.65,23.55 83.45,23.55 83.86,23.97 85.2,23.97 85.49,23.68 86.69,23.68 87.46,24.45 87.46,26.75 87.65,26.94 88.23,26.94 88.4,27.11 88.4,27.26 88.52,27.38 v2(88.68,27.38)
  IN4 w0.058: v5(28.66,19.61) 28.74,19.71 28.82,19.73 28.9,19.71 v3(29.06,19.56)
  BOTTOM w0.089: v5(28.66,19.61) 28.66,19.63 28.57,19.72 25.91,19.72 25.77,19.58 25.77,19.39 25.98,19.18 R90784.1
SOC_I2C4_1V8_SCL: length 26.6
  TOP w0.075: 80.3,36.36 U1001.Y2
  TOP w0.089: v2(78.34,36.18) 78.34,36.36 78.38,36.4 79.6,36.4 79.76,36.4 79.85,36.4 79.89,36.36 80.3,36.36
  IN2 w0.058: v2(78.34,36.18) 78.31,36.21 78.31,36.43 78.25,36.49 78.05,36.49 77.58,36.96 76.78,36.96 76.18,37.56 76.18,38.47 75.22,39.43 75.22,39.43 74.87,39.78 74.87,40.42 73.65,41.64 73.65,44.89 72.96,45.58 72.21,45.58 71.9,45.89 71.9,46.02 v3(71.66,46.26)
  IN4 w0.058: v5(69.27,47.86) 69.44,48.03 69.61,48.03 70,47.64 71.21,47.64 71.9,46.95 71.9,46.5 v3(71.66,46.26)
  BOTTOM w0.089: Q800.1 66.46,46.51 66.2,46.76 R91255.1 65.52,46.76 65.44,46.84 65.44,47.02 65.53,47.11 66.67,47.11 67.57,48.01 69.12,48.01 v5(69.27,47.86)
SOC_I2C4_1V8_SDA: length 28.8
  TOP w0.075: U1001.W2 81.03,36.7 80.83,36.49 80.36,36.49 80.36,36.5 80.34,36.5 80.31,36.54 80.3,36.54
  TOP w0.089: v2(78.34,36.92) 78.29,36.87 78.29,36.69 78.4,36.58 79.88,36.58 79.92,36.54 80.3,36.54
  IN2 w0.058: v2(78.34,36.92) 78.29,36.87 78.29,36.67 78.23,36.61 78.1,36.61 77.63,37.08 76.83,37.08 76.3,37.61 76.3,38.52 74.99,39.83 74.99,40.47 73.77,41.69 73.77,44.94 73.01,45.7 72.26,45.7 72.02,45.94 72.02,46.11 72.17,46.26 v3(72.27,46.26)
  IN4 w0.058: v5(69.27,48.32) 69.44,48.15 69.66,48.15 70.04,47.76 71.26,47.76 72.02,47 72.02,46.51 v3(72.27,46.26)
  BOTTOM w0.089: Q799.1 63.44,47.05 63.66,47.28 64.8,47.28 64.98,47.1 64.98,46.81 R91256.1 65.21,46.76 65.26,46.82 65.26,47.1 65.45,47.29 66.59,47.29 67.5,48.19 69.15,48.19 v5(69.27,48.32)
SOC_I2C5_1V8_SCL: length 132.9
  TOP w0.089: v1(91.47,26.74) R1111.2 ; v2(12.58,32.05) 12.29,32.05 U6504.D12
  IN1 w0.076: v7(89.9,33.11) 89.95,33.11 90.02,33.04 90.02,30.77 90.46,30.33 90.46,29.14 91.35,28.25 91.35,27.36 91.65,27.06 91.65,26.92 v1(91.47,26.74) 91.21,26.48 91.18,26.48 90.99,26.3 90.99,25.74 91.28,25.46 91.96,25.46 92.67,24.74 92.67,24.42 92.97,24.13 93.12,24.13 v2(93.42,23.82)
  IN2 w0.058: v2(93.42,23.82) 93.3,23.95 93.15,23.95 93.07,23.87 93.07,23.22 88.93,19.08 87.74,19.08 86.83,18.17 83.61,18.17 83.5,18.07 77.52,18.07 76.02,19.56 75.07,19.56 74.79,19.28 74.79,17.14 75.33,16.59 75.33,14.21 74.12,12.99 73.08,12.99 72.92,12.84 68.41,12.84 68,13.24 68,13.79 67.12,14.67 66.69,14.67 65.88,13.86 60.86,13.86 60.43,13.42 59.91,13.42 v3(59.7,13.21) ; v2(10.96,25.48) 10.68,25.48 v3(10.55,25.61) 10.35,25.41 10.23,25.41 10.12,25.52 10.12,26.52 11.95,28.35 11.95,32.15 11.98,32.19 12.44,32.19 12.46,32.16 12.47,32.16 v2(12.58,32.05)
  IN3 w0.102: v3(10.55,25.61) 10.31,25.37 10.03,25.37 9.71,25.05 9.71,24.54 10.12,24.14 11.08,24.14 12.25,22.97 12.25,20.87 13.88,19.25 13.88,18.87 15.49,17.26 15.49,13 16.88,11.61 31.22,11.61 31.55,11.28 32.2,11.28 32.68,11.77 41.03,11.77 41.41,12.15 44.98,12.15 45.49,11.64 47.07,11.64 48.82,9.89 52.59,9.89 52.89,10.19 58.58,10.19 60.05,11.66 60.05,12.36 59.68,12.74 59.44,12.74 59.24,12.93 59.24,13.29 59.34,13.39 59.52,13.39 v3(59.7,13.21)
SOC_I2C5_1V8_SDA: length 133
  TOP w0.089: U6504.D14 v2(12.58,32.48)
  IN1 w0.076: v7(90.24,33.16) 90.24,33.05 90.18,32.99 90.18,30.83 90.61,30.4 90.61,29.2 91.5,28.31 91.5,27.43 91.8,27.12 91.8,26.37 v1(91.47,26.04) 91.47,26.2 91.34,26.33 91.23,26.33 91.14,26.24 91.14,25.81 91.34,25.61 92.02,25.61 92.83,24.8 92.83,24.49 93.03,24.28 v2(93.42,24.28)
  IN2 w0.058: v2(10.96,25.08) 10.7,25.08 v3(10.55,24.92) 10,25.47 10,26.57 11.83,28.4 11.83,32.2 11.93,32.3 12.41,32.3 v2(12.58,32.48) ; v2(93.42,24.28) 93.21,24.07 93.1,24.07 92.96,23.92 92.96,23.27 88.89,19.2 87.69,19.2 86.78,18.29 83.56,18.29 83.45,18.18 77.56,18.18 76.07,19.68 75.02,19.68 74.67,19.33 74.67,17.09 75.22,16.54 75.22,14.26 74.07,13.11 73.03,13.11 72.87,12.95 68.45,12.95 68.12,13.29 68.12,13.84 67.17,14.79 66.65,14.79 65.83,13.98 60.82,13.98 60.38,13.54 60.01,13.54 v3(59.7,13.85)
  IN3 w0.102: v3(59.7,13.85) 59.44,13.6 59.26,13.6 59.04,13.37 59.04,12.85 59.36,12.53 59.59,12.53 59.85,12.27 59.85,11.75 58.5,10.39 52.81,10.39 52.5,10.09 48.9,10.09 47.15,11.84 45.58,11.84 45.07,12.35 41.33,12.35 40.95,11.97 32.6,11.97 32.11,11.49 31.63,11.49 31.3,11.82 16.96,11.82 15.69,13.09 15.69,17.34 14.08,18.95 14.08,19.33 12.45,20.96 12.45,23.05 11.17,24.34 10.2,24.34 9.91,24.63 9.91,24.97 10.11,25.16 10.31,25.16 v3(10.55,24.92)
SOC_I2C6_1V8_SCL: length 5.6
  TOP w0.089: R1114.2 94.98,37.47 94.88,37.37 94.72,37.37 94.55,37.55 94.24,37.55 94.04,37.75 I2C6_SCL_MTK.1 93.83,38.28 93.54,38.57 93.5,38.57 93.2,38.87 91.51,38.87 91.47,38.91 90.89,38.91 U1001.N26
SOC_I2C6_1V8_SDA: length 6
  TOP w0.089: U1001.P26 91.4,38.76 91.44,38.72 93.14,38.72 93.56,38.3 93.56,38.11 93.86,37.8 93.86,37.19 I2C6_SDA_MTK.1 94.18,37.15 94.18,37.28 94.27,37.37 94.47,37.37 94.65,37.19 94.88,37.19 94.98,37.09 R1113.2
SPI0_CLK: length 7.3
  IN1 w0.06: 81.64,33.41 81.64,33.7 v7(81.44,33.9)
  IN1 w0.076: v1(77.83,28.53) 78.36,28.53 79.82,29.99 79.82,31.18 81.64,33.01 81.64,33.41
SPI0_CSB: length 7
  TOP w0.089: R91081.1 76.82,30.58 77.28,30.13 77.53,30.13 78.02,30.62 79.05,30.62 v1(79.18,30.49)
  IN1 w0.06: v7(81.36,33.59) 81.29,33.59 80.32,32.62 80.32,32.39
  IN1 w0.076: 80.32,32.39 80.32,32.34 79.59,31.6 79.59,31.02 79.18,30.61 v1(79.18,30.49)
SPI0_MI: length 36.1
  TOP w0.089: v2(77.43,30.51) 77.43,30.54 77.75,30.86 79.66,30.86 79.89,31.1 79.89,31.36 80.73,32.2 80.73,32.23 81.03,32.54 U1001.AJ2
  IN2 w0.058: v3(64.52,33) 64.63,33.1 64.63,33.61 64.89,33.87 66.73,33.87 67.67,34.81 70.13,34.81 71.27,33.66 72.73,33.66 74.87,31.52 74.87,30.25 75.59,29.52 76.69,29.52 77.43,30.26 v2(77.43,30.51) ; v2(59.32,23.55) 58.88,23.55 v3(58.81,23.63)
  IN3 w0.102: v3(58.81,23.63) 58.81,23.77 58.91,23.87 58.91,24.6 61.75,27.44 64.32,27.44 64.42,27.54 64.42,32.87 64.52,32.98 v3(64.52,33)
SPI0_MO: length 3.5
  TOP w0.06: 80.73,31.96 80.73,31.99 80.97,32.22 80.97,32.28 81.31,32.63 81.31,32.88 U1001.AH2
  TOP w0.089: 80.73,31.96 80.73,31.88 80.04,31.19 80.04,30.84 R91080.1
SPI2_CLK: length 4.5
  TOP w0.075: 79.81,32.78 80.13,33.1 80.13,33.37 80.56,33.8 80.8,33.8 U1001.AG2
  TOP w0.089: R90336.1 78.06,32.59 78.55,32.59 78.57,32.57 79.61,32.57 79.75,32.71 79.81,32.77 79.81,32.78
SPI2_CSB: length 6.5
  IN1 w0.06: v7(82.24,35.56) 82.03,35.36 81.73,35.36 81.71,35.38 81.33,35.38 80.55,34.6 80.04,34.6 79.61,34.17
  IN1 w0.076: v1(78.72,31.25) 78.72,31.49 78.8,31.57 78.8,32.7 79.61,33.52 79.61,34.17
SPI2_MI: length 101.3
  IN1 w0.06: 80.25,33.18 80.25,33.21 81.35,34.3 v7(81.47,34.3)
  IN1 w0.076: 80.25,33.18 79.61,32.55 v2(79.61,32.39)
  IN2 w0.058: v2(79.61,32.39) 79.33,32.67 76.61,32.67 v3(76.44,32.49) ; v2(126.35,45.25) 126.32,45.25 v3(126.09,45.47)
  IN3 w0.102: v3(76.44,32.49) 76.44,32.95 75.96,33.43 75.96,42.56 74.76,43.76 74.76,44.93 74.05,45.64 74.05,46.74 73.34,47.45 73.34,54.39 72.02,55.71 72.02,56.56 76.57,61.12 78.42,61.12 79.33,62.03 87.49,62.03 87.61,61.91 89.77,61.91 89.9,62.03 93.12,62.03 93.16,61.98 94.6,61.98 95.08,62.46 115.13,62.46 117.28,60.32 117.28,56.55 118.36,55.47 118.36,54.05 119.32,53.09 120.48,53.09 120.84,52.74 120.84,49.01 123.36,46.49 125.08,46.49 v3(126.09,45.47)
SPI2_MO: length 8.8
  IN1 w0.06: 79.96,34.72 80.5,34.72 81.34,35.56 v7(81.83,35.56)
  IN1 w0.076: 79.96,34.72 79.66,34.42 79.25,34.42 78.57,33.74 78.57,31.66 78.38,31.47 78.38,30.9 78.21,30.74 78.21,30.23 77.96,29.98 77.96,29.34 v1(77.83,29.22)
SPI_AP_EC_CLK: length 97.2
  IN2 w0.058: v2(77.07,32.12) 76.83,31.88 76.69,31.88 v3(76.67,31.91) ; v2(125.34,48.42) 125.34,48.35 125.46,48.22 v3(125.46,48.11)
  IN3 w0.102: v3(76.67,31.91) 76.64,31.91 76.56,31.98 76.23,31.98 75.97,32.25 75.97,33.06 75.7,33.33 75.7,42.46 74.51,43.66 74.51,44.82 73.8,45.53 73.8,46.64 73.08,47.35 73.08,54.26 71.76,55.58 71.76,56.67 76.46,61.37 78.31,61.37 79.22,62.28 87.59,62.28 87.71,62.16 89.67,62.16 89.79,62.28 93.22,62.28 93.27,62.24 94.5,62.24 94.98,62.72 115.24,62.72 117.53,60.42 117.53,56.66 118.62,55.58 118.62,54.15 119.42,53.35 120.59,53.35 121.09,52.85 121.09,49.12 123.34,46.87 125.28,46.87 125.59,47.17 125.59,47.99 v3(125.46,48.11)
SPI_AP_EC_CS_L: length 98.9
  TOP w0.089: v2(76.96,30.95) 77.08,30.95 77.28,31.16 77.59,31.16 77.61,31.17 77.91,31.17 77.99,31.25 R90337.2
  IN2 w0.058: v2(124.84,48.42) 124.54,48.13 v3(124.54,48.09) ; v3(76.61,30.92) 76.65,30.95 v2(76.96,30.95)
  IN3 w0.102: v3(124.54,48.09) 124.42,47.96 122.97,47.96 121.6,49.33 121.6,53.06 120.8,53.85 119.64,53.85 119.12,54.37 119.12,55.79 118.04,56.87 118.04,60.63 115.45,63.23 94.77,63.23 94.29,62.74 93.48,62.74 93.43,62.79 89.58,62.79 89.46,62.67 87.93,62.67 87.8,62.79 79.01,62.79 78.1,61.88 76.25,61.88 71.26,56.89 71.26,55.33 72.58,54.01 72.58,47.14 73.29,46.43 73.29,45.32 74,44.61 74,43.45 75.19,42.25 75.19,33.12 75.46,32.85 75.46,31.03 75.86,30.63 76.31,30.63 76.59,30.92 v3(76.61,30.92)
SPI_AP_EC_MISO: length 2.9
  TOP w0.089: U6517.A4 125.84,46.21 R90339.2
SPI_AP_EC_MOSI: length 101.4
  TOP w0.089: R90338.2 77.25,29.22 76.67,29.8 76.27,29.8 76.18,29.89 76.18,31.18 76.27,31.27 v2(76.28,31.27)
  IN2 w0.058: v3(125,47.68) 125.03,47.68 125.13,47.58 125.79,47.58 126.09,47.89 126.09,49.16 v2(125.84,49.42) ; v2(76.28,31.27) v3(75.93,31.27)
  IN3 w0.102: v3(125,47.68) 125,47.66 124.85,47.5 123.06,47.5 121.34,49.22 121.34,52.95 120.7,53.6 119.53,53.6 118.87,54.26 118.87,55.68 117.79,56.76 117.79,60.53 115.34,62.97 94.87,62.97 94.39,62.49 93.37,62.49 93.33,62.54 89.68,62.54 89.56,62.41 87.82,62.41 87.7,62.54 79.12,62.54 78.2,61.63 76.36,61.63 71.51,56.78 71.51,55.45 72.83,54.13 72.83,47.24 73.54,46.53 73.54,45.43 74.25,44.72 74.25,43.55 75.45,42.36 75.45,33.22 75.71,32.96 75.71,31.75 75.9,31.55 75.9,31.3 v3(75.93,31.27)
SPK_L_N:
  vias: v6(23.81,7.88) v6(24.21,8.46)
SPK_L_P:
  vias: v6(21.8,8.39) v6(21.83,7.68)
SPK_R_N:
  vias: v6(28.68,7.93) v6(29.07,8.72)
SPK_R_P:
  vias: v6(27.24,8.13) v6(27.67,8.72)
SRCLKENA0: length 96.1
  TOP w0.089: R90525.1 124.49,44.94 124.49,43.01 v2(124.42,42.93)
  IN2 w0.058: v3(104.4,29.62) 105.16,28.86 105.16,27.21 105.78,26.59 107.29,26.59 107.37,26.68 108.59,26.68 109.05,27.13 109.53,27.13 110.22,27.82 114.72,27.82 115.33,28.43 117.67,28.43 118.53,27.56 119.66,27.56 119.92,27.82 119.92,32.06 120.19,32.33 120.19,33.1 121.24,34.14 121.24,34.53 122.69,35.97 122.69,41.2 v2(124.42,42.93) ; v3(111.01,37.81) 110.78,37.58 110.78,36.87 111.06,36.59 111.06,35.67 110.8,35.41 110.35,35.41 110.02,35.74 110.02,37.24 109.96,37.3 109.48,37.3 109.32,37.46 109.32,37.78 109.21,37.9 108.68,37.9 108.57,38.01 108.06,38.01 v8(108.02,38.05)
  IN2 w0.06: 93.33,39.17 93.24,39.26 90.16,39.26 89.81,38.91 89.81,38.63 89.55,38.36 v8(89.44,38.36)
  IN2 w0.075: 93.33,39.17 93.41,39.09 93.94,39.09 94.33,38.7 94.33,38.47 94.56,38.24 94.56,37.39 94.01,36.84 94.01,36.29 94.79,35.51 96.38,35.51 97.14,34.75 97.14,31.76 97.23,31.67 97.23,29.96 97.93,29.27 97.93,28.21 98.45,27.69 98.45,26.61 99.37,25.68 99.37,25.1 100.08,24.39 100.95,24.39 101.3,24.75 103.67,24.75 104.5,25.58 104.5,26.52 104,27.03 104,27.89 102.82,29.07 102.82,30.11 102.99,30.28 102.99,30.41 103.17,30.6 103.56,30.6 104.4,29.75 v3(104.4,29.62)
  IN3 w0.102: v3(104.4,29.62) 104.61,29.83 106.51,29.83 106.66,29.98 106.66,34.93 107.45,35.72 107.45,36.94 107.58,37.06 108.49,37.06 108.97,37.55 109.35,37.55 109.65,37.24 110.44,37.24 v3(111.01,37.81)
SRCLKENA1: length 39.8
  IN1 w0.06: 108.11,34.62 107.88,34.86 107.88,36.35 107.84,36.39 107.84,36.74 107.82,36.76 107.82,37.39 v7(107.22,37.99) ; v7(89.83,38.36) 90.03,38.56 90.32,38.56 90.7,38.95 90.99,38.95 91.08,39.04 93.14,39.04 93.94,38.24 93.94,37.95
  IN1 w0.076: 108.11,34.62 108.11,34.14 108.23,34.02 108.23,33.44 107.86,33.07 107.86,32.08 108.07,31.87 108.07,31.04 108.48,30.64 108.48,29.63 108.11,29.27 108.11,28.96 108.26,28.81 108.26,27.46 107.37,26.57 105.93,26.57 105.49,26.14 99.88,26.14 95.41,30.61 95.41,32.57 94.51,33.47 94.51,34.51 94.22,34.8 94.22,35.82 94.03,36 94.03,37.17 93.94,37.26 93.94,37.95
SYS_RST_ODL: length 91.6
  TOP w0.089: v2(51.43,14.48) 51.43,14.57 52.76,15.9 U124.A2 ; v2(102.22,24.39) 102.22,24.54 102.66,24.98 D2708.1
  IN2 w0.058: v2(102.22,24.39) 101.86,24.39 v3(101.81,24.34) ; v3(51.43,14.81) v2(51.43,14.48)
  IN3 w0.102: v3(47.99,26.6) 48.29,26.6 48.85,26.04 59.2,26.04 61.41,28.25 61.53,28.25 62.16,28.88 62.16,29.75 61.81,30.1 61.81,32.24 63.79,34.22 65.64,34.22 66.2,33.66 66.2,27.97 66.73,27.44 69.78,27.44 78.07,19.15 87.12,19.15 88.04,20.07 91.39,20.07 92.56,21.23 98.18,21.23 101.01,24.06 101.25,24.06 101.51,24.31 101.79,24.31 v3(101.81,24.34)
  IN4 w0.058: v5(51.1,14.81) v3(51.43,14.81) ; v3(47.99,26.6) 48.4,26.6 v4(48.52,26.47)
  IN5 w0.076: v5(49.64,16.29) 49.47,16.46 49.47,25.52 v4(48.52,26.47)
  BOTTOM w0.089: v5(49.64,16.29) 50.08,16.29 50.3,16.52 R90913.1 50.91,16.13 50.91,15.37 51.1,15.18 v5(51.1,14.81)
SYS_RST_ODL_R: length 0.9
  BOTTOM w0.089: U6548.8 R90969.1
SYSRSTB: length 27.2
  TOP w0.089: D2708.2 104.36,26.84 104.43,26.91 R90582.2 104.43,27.77 104.66,28 104.66,29.18 104.07,29.77 R90581.1 103.87,30.07 v1(103.87,30.08)
  IN1 w0.06: v7(89.43,40.36) 89.64,40.56 90.96,40.56 91.09,40.7 91.52,40.7
  IN1 w0.076: v1(103.87,30.08) 103.62,30.33 103.62,30.41 103.43,30.6 103.43,30.6 103.03,30.99 100.69,30.99 99.83,31.86 99.71,31.86 98.66,32.91 98.66,34.99 97.86,35.79 97.86,36.6 97.33,37.14 97.33,39.51 96.34,40.5 96.34,40.63 95.77,41.2 95.18,41.2 94.98,41.41 94.45,41.41 94.24,41.61 92.9,41.61 91.98,40.7 91.52,40.7
TABLET_MODE_L: length 53.5
  IN1 w0.076: v2(123.93,55) 124.19,54.74 125.2,54.74 125.42,54.53 128.73,54.53 129.19,54.06 129.19,53.74 131.11,51.82 131.89,51.82 132.24,51.47 132.24,50.09 132.57,49.76 132.57,40.34 135.47,37.45 139.15,37.45 140.97,35.63 140.97,29.87 v2(140.7,29.6) ; v1(128,66.71) 127.47,66.18 127.47,65.36 125.97,63.86 125.97,60.03 125.69,59.75 125.69,59.01 v2(123.76,57.08)
  IN2 w0.058: v2(140.7,29.6) 140.7,29.22 v3(140.7,29.22) ; v2(123.93,55) 123.93,55.56 123.35,56.14 123.35,56.67 v2(123.76,57.08)
  IN4 w0.058: v5(141.24,29.72) 140.73,29.22 v3(140.7,29.22)
  BOTTOM w0.089: R9572.1 v5(141.24,29.72)
THRM_SET: length 3.1
  BOTTOM w0.254: R91321.1 R91322.1 72.64,40.89 72.36,41.17 U6581.1
TOUCH_INT_ODL: length 107.7
  TOP w0.089: v1(52.1,48.47) 52.03,48.55 50,48.55 49.77,48.32 Q778.4 49.49,47.98 49.11,48.36 R91130.2 48.32,48.36 48.23,48.27 R91135.1
  IN1 w0.076: v1(52.1,48.47) 52.1,48.49 52.36,48.75 60.26,48.75 61.17,47.83 61.17,47.25 61.43,47 62.6,47 63.13,47.52 v2(63.13,47.63)
  IN2 w0.058: v8(89.04,38.76) 89.23,38.56 89.54,38.56 89.7,38.71 89.7,38.96 90.12,39.38 93.32,39.38 93.48,39.22 94.01,39.22 94.46,38.78 94.46,38.55 94.69,38.32 94.69,36.92 95.03,36.58 95.51,36.58 95.65,36.72 96.13,36.72 96.39,36.98 97.25,36.98 97.7,36.53 97.7,35.61 97.36,35.27 97.36,31.85 97.45,31.76 97.45,30.08 98.14,29.38 98.14,28.31 98.67,27.78 98.67,26.7 99.77,25.6 v3(99.77,25.27) ; v2(63.13,47.63) 63.84,47.63 v3(63.95,47.75)
  IN3 w0.102: v3(99.77,25.27) 99.58,25.08 99.58,24.35 97.68,22.45 92.04,22.45 90.87,21.28 87.53,21.28 86.62,20.37 78.58,20.37 71.41,27.54 71.41,28.28 70.39,29.3 70.39,29.58 69.18,30.79 68.31,30.79 67.42,31.68 67.42,34.17 66.15,35.44 61.5,35.44 61.2,35.74 61.2,36.46 61.6,36.86 61.6,39.27 62.54,40.21 63.66,40.21 63.99,40.54 63.99,41.17 63.6,41.56 63.6,41.58 63.09,42.1 63.09,42.37 61.58,43.88 61.58,44.91 63.61,46.94 63.61,47.35 63.98,47.72 63.98,47.72 v3(63.95,47.75)
TOUCH_INT_ODL_R: length 16.3
  TOP w0.089: R91135.2 48.41,46.95 50.3,46.95 50.64,47.28 Q778.1 51.13,47.28 51.26,47.15 R91129.2
  IN2 w0.058: v3(52.13,46.9) 52.06,46.9 v2(51.8,47.15)
  IN4 w0.058: v3(52.13,46.9) 51.95,46.9 51.45,46.39 51.45,39.78 52.42,38.81 v5(52.42,38.16)
  BOTTOM w0.089: J15.38 52.55,37.74 52.42,37.86 v5(52.42,38.16)
TOUCH_RST_3V3_ODL: length 17.5
  TOP w0.089: Q779.1 55.17,47.28 55.56,46.89 56.09,46.89 56.22,47.02 v2(56.22,47.16) R91132.2 56.22,47.44 56.63,47.86 R91133.2
  IN2 w0.058: v3(55.35,47) 56.05,47 v2(56.22,47.16)
  IN4 w0.058: v5(52.84,38.11) 52.84,39.67 53.84,40.67 53.84,45.27 53.22,45.89 53.22,46.56 53.65,47 v3(55.35,47)
  BOTTOM w0.089: v5(52.84,38.11) 52.84,37.83 53.05,37.62 J15.39
TOUCH_RST_L_1V8: length 95.6
  TOP w0.152: Q779.4 53.19,47.98 53.07,47.86 R91131.2
  IN1 w0.076: v2(63.53,47.99) 63.53,47.58 62.73,46.77 61.33,46.77 60.94,47.16 60.94,47.74 60.37,48.32 v1(55.79,48.32) 55.61,48.49 53.2,48.49 v1(52.64,47.94)
  IN2 w0.058: v3(64.27,48.27) 63.81,48.27 v2(63.53,47.99)
  IN2 w0.06: 93.18,38.92 93.08,39.02 90.26,39.02 90.05,38.81 90.05,38.5 89.51,37.96 v8(89.44,37.96)
  IN2 w0.075: v3(99.04,24.49) 98.92,24.62 98.92,25.5 97.99,26.42 97.99,27.5 97.47,28.03 97.47,29.06 96.75,29.78 96.75,31.49 96.68,31.55 96.68,34.56 96.19,35.06 94.6,35.06 93.45,36.2 93.45,36.92 94.28,37.75 94.28,38.12 94.04,38.36 94.04,38.6 93.82,38.82 93.28,38.82 93.18,38.92
  IN3 w0.102: v3(99.04,24.49) 99.04,24.25 97.55,22.76 91.91,22.76 90.74,21.59 87.4,21.59 86.49,20.68 78.7,20.68 71.71,27.66 71.71,28.41 70.7,29.42 70.7,29.71 69.31,31.1 68.43,31.1 67.72,31.81 67.72,34.3 66.05,35.97 66.05,38.74 64.3,40.49 64.3,41.29 63.91,41.68 63.91,41.71 63.39,42.22 63.39,42.49 62.85,43.04 62.85,43.57 63.99,44.71 63.99,46.16 64.5,46.67 64.5,48.04 v3(64.27,48.27)
TPAD_INT_N: length 8.4
  TOP w0.089: Q732.2 53.75,4.18 53.6,4.32 52.99,4.32 52.84,4.47 v2(52.84,4.83)
  IN2 w0.058: v2(52.84,4.83) v3(53.17,4.83)
  IN4 w0.058: v3(53.17,4.83) v5(53.5,4.83)
  BOTTOM w0.089: CON12.2 57.15,8.1 53.88,4.83 v5(53.5,4.83)
TPAD_SCL: length 4.5
  TOP w0.089: v2(55.1,7.35) 54.72,7.72 R9499.2 Q730.2
  IN2 w0.058: v3(56.63,8.76) 55.21,7.35 v2(55.1,7.35)
  IN4 w0.058: v5(56.15,9.25) 56.15,9.22 56.6,8.76 v3(56.63,8.76)
TPAD_SDA: length 4.7
  TOP w0.089: Q731.2 54.21,6.2 54.34,6.33 v2(54.47,6.33)
  IN2 w0.058: v3(56.02,8.76) 56.02,8.71 54.52,7.21 54.52,6.38 v2(54.47,6.33)
  IN4 w0.058: v5(55.65,9.25) 56.02,8.88 v3(56.02,8.76)
TRACKPAD_BTN_L: length 1.7
  BOTTOM w0.089: TP9142.1 58.56,9.91 57.77,9.91 57.65,9.79 CON12.1
TRACKPAD_INT_1V8_ODL: length 80.1
  TOP w0.075: U1001.AE1 80.46,34.53 80.17,34.53 79.86,34.22 79.82,34.22
  TOP w0.089: Q734.2 51.08,3.49 50.91,3.66 50.91,4.12 51.45,4.65 R91212.2 50.94,5.34 50.53,5.34 50.15,5.72 50.15,5.95 v2(50.17,5.98) ; 79.82,34.22 79.51,34.22 v2(79.36,34.07)
  IN2 w0.058: v2(50.17,5.98) 51.09,5.98 51.53,6.42 51.53,7.48 51.37,7.65 51.37,8.08 51.78,8.49 51.97,8.49 52.53,9.04 52.53,10.21 53.54,11.22 57.49,11.22 57.95,11.68 58.27,11.68 58.86,12.27 v3(58.86,12.38) ; v2(79.36,34.07) 79.23,34.07 78.88,33.71 78.21,33.71 76.74,35.19 76.43,35.19 73.4,38.21 68.15,38.21 67.68,38.68 62.43,38.68 61.45,37.7 58.63,37.7 58.23,37.29 v3(57.41,37.29)
  IN4 w0.058: v4(58.68,12.66) 58.86,12.48 v3(58.86,12.38) ; v4(57.55,37) 57.55,37.15 v3(57.41,37.29)
  IN5 w0.076: v4(58.68,12.66) 58.68,12.83 57.01,14.51 56.24,14.51 55.53,15.22 55.53,16.21 54.5,17.24 53.13,17.24 52.71,17.66 52.71,18.65 52.09,19.28 52.09,19.52 51.63,19.98 51.63,21.21 51.63,25.02 53.37,26.75 58.29,26.75 60.23,28.7 60.23,34.22 57.55,36.9 v4(57.55,37)
TX0N: length 4.3
  TOP w0.071: U1.35 22.73,21.12 22.66,21.05 19.66,21.05 C10704.1
TX0P: length 4.3
  TOP w0.071: U1.36 22.75,20.72 22.65,20.83 19.67,20.83 C10703.1
TX1N: length 2.9
  TOP w0.071: C10700.1 20.92,21.96 21.8,21.96 22.07,22.23 22.67,22.23 22.76,22.32 U1.32
TX1P: length 2.9
  TOP w0.071: C10699.1 20.92,21.74 21.89,21.74 22.17,22.01 22.68,22.01 22.77,21.92 U1.33
TX2N: length 1.8
  TOP w0.071: U1.29 22.87,23.52 22.77,23.42 22.46,23.42 22.15,23.12 22.06,23.12 C10702.1
TX2P: length 1.8
  TOP w0.071: U1.30 22.81,23.12 22.74,23.2 22.55,23.2 22.24,22.89 22.08,22.89 C10701.1
TX3N: length 3.7
  TOP w0.071: C10706.1 20.59,23.73 20.83,23.73 21.23,24.14 21.43,24.14 21.93,24.63 22.68,24.63 22.77,24.72 U1.26
TX3P: length 3.7
  TOP w0.071: C10705.1 20.57,23.51 20.92,23.51 21.32,23.91 21.53,23.91 22.03,24.41 22.64,24.41 22.73,24.32 U1.27
TX_AVCC: length 8.4
  TOP w0.178: U1.37 22.77,20.32 22.67,20.43 v2(22.44,20.43) ; v2(22.51,23.92) U1.28 ; U1.34 v2(22.51,21.52) ; v2(22.52,22.72) U1.31 ; v2(22.39,25.12) U1.25
  IN2 w0.178: v3(22.93,23.92) v2(22.51,23.92) ; v3(22.72,25.12) v2(22.39,25.12) ; v3(23.1,23.12) 23.1,23.07 22.75,22.72 v2(22.52,22.72) ; v3(22.89,21.52) v2(22.51,21.52) ; v3(22.82,20.5) 22.51,20.5 v2(22.44,20.43)
  IN4 w0.178: v5(23.05,25.12) v3(22.72,25.12) ; v5(23.27,22.72) 23.27,22.79 23.1,22.97 v3(23.1,23.12) ; v3(22.82,20.5) 22.85,20.47 v5(23.17,20.47) ; v5(23.22,21.52) v3(22.89,21.52) ; v5(23.26,23.92) v3(22.93,23.92)
  vias: v1(21.6,20.38) v1(21.6,20.07) v1(21.9,20.38) v1(21.9,20.07) v2(21.6,20.38) v2(21.6,20.07) v2(21.9,20.38) v2(21.9,20.07)
TX_OVDD: length 18.5
  TOP w0.152: U1.18 25.83,27.59 25.39,28.02 24.77,28.02 24.67,28.12 24.67,29.29 R90580.2 ; 31.66,27.74 31.43,27.52 U1.4 ; U1.64 31.83,15.85 v2(31.81,15.83)
  IN2 w0.152: v3(32.11,16.52) 31.83,16.23 31.83,15.85 v2(31.81,15.83) ; v2(38.01,20.94) 38.29,20.66 v3(38.29,20.61) ; v5(25.66,17.91) v3(25.31,17.91) ; v2(27.34,15.8) v3(27.34,16.16) ; v2(38.01,17.69) 38.01,17.66 37.8,17.46 v3(37.8,17.43) ; v2(24.14,16.62) 23.91,16.39 v3(23.9,16.39)
  IN4 w0.152: v5(38.13,16.57) 38.28,16.71 38.28,17.24 38.06,17.46 37.83,17.46 v3(37.8,17.43) ; v3(23.9,16.39) v5(24.23,16.39) ; v3(24.62,29.3) v5(24.62,28.97) ; v3(27.34,16.16) 27.47,16.16 v5(27.67,16.36) ; v3(25.31,17.91) v5(25.66,17.91) ; v5(32.11,16.92) v3(32.11,16.52)
  BOTTOM w0.152: C8.1 C7.1 24.61,28.96 v5(24.62,28.97) ; C10576.1 38.44,16.56 38.44,16.57 v5(38.13,16.57) ; R90155.2 26.81,16.37 C4.1 ; v5(24.23,16.39) 24.23,16.81 24.62,17.2 Q3.2 ; Q4.2 v5(25.66,17.91)
  BOTTOM w0.203: v6(34.88,24.57) 34.58,24.26 C1.1 C9017.1
  vias: v1(23.2,16.82) v1(23.2,16.52) v1(23.45,16.82) v1(23.45,16.52) v1(23.71,16.82) v1(24.34,29.67) v1(29.4,36.12) v1(29.4,35.87) v1(29.65,36.12) v1(29.65,35.87) v2(24.34,29.67) v6(31.91,27.74) v6(32.62,27.74)
TX_PVCC0: length 4.2
  TOP w0.203: U1.41 22.46,18.72 22.11,18.37 v2(22.11,18.22)
  IN2 w0.203: v3(22.21,17.76) 22.11,17.86 v2(22.11,18.22)
  IN4 w0.203: v3(22.21,17.76) 22.05,17.6 v5(22.05,17.41)
  BOTTOM w0.203: FB2.2 21.83,16.13 22.05,16.36 C16.1 v5(22.05,17.41)
TX_PVCC1: length 4.3
  TOP w0.178: v2(22.36,19.57) 22.71,19.57 22.76,19.52 U1.39
  IN2 w0.178: v2(22.36,19.57) 22.68,19.57 22.69,19.59 v3(22.72,19.59)
  IN4 w0.178: v3(22.72,19.59) 22.7,19.59 22.69,19.6 22.69,19.82 v5(22.59,19.92)
  BOTTOM w0.178: v5(22.59,19.92) 22.31,20.2 C14.1 C13.1 20.49,20.2 FB3.2
TX_PVCC2: length 4.1
  TOP w0.203: v2(22.39,19.16) 22.42,19.12 U1.40
  IN2 w0.203: v2(22.39,19.16) 22.41,19.13 23.07,19.13 v3(23.12,19.08)
  IN4 w0.203: v5(22.72,18.65) 22.72,18.68 v3(23.12,19.08)
  BOTTOM w0.203: v5(22.72,18.65) C18.1 21.38,18.65 FB4.2
TX_XVCC18: length 3.6
  TOP w0.203: U1.42 22.62,18.32 v2(22.51,18.22)
  IN2 w0.203: v3(22.82,17.76) 22.82,17.91 v2(22.51,18.22)
  IN4 w0.203: v3(22.82,17.76) 22.82,17.63 22.62,17.43 v5(22.62,17.41)
  BOTTOM w0.203: v5(22.62,17.41) C12.1 22.62,16.01 FB5.2
TXAUXN: length 2.3
  TOP w0.071: C9036.1 21.54,25.66 21.94,25.66 22.09,25.81 22.64,25.81 22.75,25.92 U1.23
TXAUXP: length 2.2
  TOP w0.071: C9035.1 21.57,25.44 22.04,25.44 22.19,25.59 22.68,25.59 22.74,25.52 U1.24
UART_AP_TX_DBG_RX: length 78.4
  TOP w0.075: 80.08,34.76 80.09,34.76 U1001.AD1
  TOP w0.089: v2(47.28,5.34) 47.36,5.26 R332.1 ; v2(79.31,34.75) 79.56,34.5 79.83,34.5 80.08,34.76 ; v2(46.67,26.65) 47.07,26.24 47.07,25.66 48.39,24.35 50.69,24.35 50.78,24.26 50.78,22.64 51.88,21.54 R90389.1 51.88,21.08 52.36,20.6 52.36,20 v2(52.59,19.77)
  IN2 w0.058: v3(46.33,26.58) 46.35,26.58 46.42,26.65 v2(46.67,26.65) ; v2(52.59,19.77) 52.59,19.75 52.16,19.33 51.98,19.33 51.7,19.05 50.81,19.05 49.23,17.47 49.23,17.21 47.79,15.76 47.79,14.11 47.39,13.71 47.39,12.65 47.1,12.35 47.1,7.54 47.69,6.95 47.69,6.46 47.87,6.28 47.87,5.76 47.45,5.34 v2(47.28,5.34) ; v3(45.51,34.54) 46.17,34.54 46.97,35.34 52.37,35.34 52.88,35.85 55.84,35.85 56.07,36.07 56.07,36.28 56.47,36.68 56.47,37.29 56.9,37.73 58.28,37.73 58.46,37.91 61.36,37.91 62.34,38.89 67.78,38.89 68.25,38.42 73.49,38.42 76.48,35.44 76.82,35.44 78.32,33.94 78.79,33.94 79.31,34.46 v2(79.31,34.75)
  IN4 w0.058: v3(45.51,34.54) 45.88,34.17 45.88,32.75 v4(45.65,32.52) ; v3(46.33,26.58) 46.06,26.85 v4(46.01,26.85)
  IN5 w0.076: v4(45.65,32.52) 45.65,27.34 46.01,26.98 v4(46.01,26.85)
UART_BT_WAKE_ODL: length 94.4
  IN1 w0.06: 80.91,41.29 81.26,40.93 81.57,40.93 81.59,40.96 82.04,40.96 82.21,40.79 v7(82.21,40.76)
  IN1 w0.076: v2(73.36,50.98) 73.44,50.91 73.44,45.61 75.52,43.53 77.24,43.53 78.18,42.58 v1(78.96,42.58) 79.54,42.58 80.83,41.29 80.91,41.29
  IN2 w0.058: v3(131.94,60.97) 131.43,60.46 131.17,60.46 129.45,62.18 128.77,62.18 128.16,62.79 125.37,62.79 124.44,61.86 122.53,61.86 122.28,62.11 120.51,62.11 119.82,62.8 117.73,62.8 116.54,63.99 77.95,63.99 76.94,62.98 76.94,61.98 74.36,59.39 74.36,51.98 v2(73.36,50.98)
  IN4 w0.058: v3(131.94,60.97) v5(132.32,60.97)
  BOTTOM w0.089: v5(132.32,60.97) 137.25,60.97 137.89,60.33 U1007.53
UART_DBG_RXD_WLAN: length 1.2
  BOTTOM w0.089: R91134.1 134.17,49.33 134.28,49.22 U1007.29
UART_DBG_TX_AP_RX: length 76.2
  TOP w0.075: 80.3,35 80.8,35 U1001.AD2
  TOP w0.089: R90388.1 52.72,21.69 52.68,21.73 52.07,21.73 51.04,22.76 51.04,24.38 50.83,24.59 48.49,24.59 47.32,25.76 47.32,26.36 v2(47.51,26.55) ; v2(79.71,34.83) 79.89,34.83 80.06,35 80.3,35
  IN2 w0.058: v2(47.51,26.55) 47.48,26.57 47.23,26.57 v3(47.18,26.63) ; v2(79.71,34.83) 79.36,35.19 79.21,35.19 78.98,34.96 78.98,34.42 78.72,34.17 78.39,34.17 76.87,35.69 76.52,35.69 73.58,38.63 68.33,38.63 67.87,39.1 62.25,39.1 61.28,38.12 58.28,38.12 58.11,37.95 56.35,37.95 54.64,36.25 52.99,36.25 52.3,35.57 46.44,35.57 45.93,35.06 45.93,35.03 v3(45.91,35.01)
  IN4 w0.058: v3(45.91,35.01) 46.34,34.58 46.34,32.64 v4(46.15,32.45) ; v3(47.18,26.63) 47.18,26.32 v4(47.15,26.3)
  IN5 w0.076: v5(45.83,12.21) 49.25,15.62 49.25,24.81 47.76,26.3 v4(47.15,26.3) 47.02,26.3 45.88,27.44 45.88,32.19 v4(46.15,32.45)
UART_DBG_TX_EC_RX: length 132.2
  IN1 w0.076: v2(118.64,18.46) 119.03,18.85 119.03,21.42 118.4,22.05 118.4,25.74 118.83,26.17 118.83,26.73 120.03,27.92 120.03,35.08 119.26,35.85 119.26,40.75 122.16,43.64 122.16,44.56 123.07,45.47 123.38,45.47 123.81,45.9 123.81,46.49 124.24,46.92 124.24,48.62 124.84,49.22 v1(124.84,49.42)
  IN2 w0.058: v2(59.7,15.14) 59.55,15.3 59.55,16.31 59.9,16.67 60.89,16.67 61.4,17.18 v3(61.4,17.28) ; v2(118.64,18.46) 118.63,18.46 v3(118.31,18.14)
  IN3 w0.102: v3(118.31,18.14) 118.22,18.05 118.22,16.78 115.49,14.05 114.24,14.05 113.89,13.7 113.39,13.7 109.74,10.04 100.03,10.04 99.68,9.68 97.66,9.68 97.05,9.07 91.88,9.07 89.64,11.31 87.72,11.31 86.56,12.46 69.73,12.46 69.49,12.22 64.58,12.22 62.59,14.21 62.59,17.11 62.43,17.28 v3(61.4,17.28) 60.51,17.28 59.85,17.94 58.68,17.94 57.54,19.08 55.01,19.08 54.39,19.7 52.44,19.7 51.75,19.01 51.75,16.87 51.44,16.57 50.78,16.57 50.71,16.64 47.28,16.64 46.95,16.31 43.85,16.31 v3(43.72,16.44)
  IN4 w0.058: v3(43.72,16.44) 42.07,14.79 v5(42.07,13.87)
  BOTTOM w0.089: R90439.2 42.53,12.82 42.44,12.91 42.4,12.91 42.07,13.24 v5(42.07,13.87)
UART_DBG_TXD_WLAN: length 4.4
  TOP w0.089: R90843.1 133.99,49.79 133.31,50.48 v2(133.12,50.48)
  IN2 w0.058: v2(133.12,50.48) 133.12,50.46 133.03,50.37 v3(133.03,50.15)
  IN4 w0.058: v3(133.03,50.15) 133.1,50.07 v5(133.1,49.82)
  BOTTOM w0.089: v5(133.1,49.82) 134.32,49.82 134.42,49.72 U1007.30
UART_EC_TX_DBG_RX: length 133.1
  TOP w0.089: v2(58.52,15.44) 58.52,15.28 59.06,14.74 59.57,14.74 59.72,14.59 R90442.1 59.89,14.33 60.03,14.47 60.03,15.46 60.22,15.65 60.64,15.65 60.75,15.77 v2(60.75,17.24) ; R90438.1 42.98,3.35 43.14,3.35 43.62,3.83 43.62,5.09 v2(43.67,5.14)
  IN1 w0.076: v1(124.34,49.42) 123.58,48.67 123.58,48.43 122.83,47.68 122.83,45.94 121.52,44.63 121.52,43.67 119.21,41.36 119.2,41.36 118.75,40.91 118.75,32.67 118.59,32.5 118.59,28.7 118.37,28.48 118.37,26.42 117.94,25.99 117.94,19.67 v2(117.84,19.56)
  IN2 w0.058: v3(118.22,19.56) v2(117.84,19.56) ; v2(43.67,5.14) 43.67,4.45 43.92,4.2 47.2,4.2 48.75,5.75 48.75,6.87 49.21,7.33 49.21,8.34 50.02,9.14 50.02,10.99 51.21,12.19 51.21,13.65 51.59,14.02 53.88,14.02 54.36,14.5 56.14,14.5 56.53,14.89 56.77,14.89 57.16,14.5 57.48,14.5 58.42,15.44 v2(58.52,15.44) ; v2(60.75,17.24) 60.84,17.33 v3(60.84,18.04)
  IN3 w0.102: v3(60.84,18.04) 62.53,18.04 63.2,17.36 63.2,14.46 63.67,13.99 65.42,13.99 66.58,12.83 69.24,12.83 69.48,13.07 86.82,13.07 87.97,11.92 89.9,11.92 91.42,10.4 98.59,10.4 99.75,11.56 110.4,11.56 113.14,14.31 113.63,14.31 113.99,14.66 115.23,14.66 117.46,16.88 117.46,19.06 117.97,19.56 v3(118.22,19.56)
UART_H1_TX_SERVO_RX: length 24.1
  TOP w0.089: U124.B9 53.96,19.41 53.6,19.77 53.15,19.77 v2(53.07,19.69)
  IN2 w0.058: v2(53.07,19.69) 52.81,19.44 52.57,19.44 52.25,19.11 52.07,19.11 51.79,18.84 50.89,18.84 49.46,17.41 49.46,17.14 48,15.68 48,14.02 47.6,13.63 47.6,12.56 47.31,12.26 47.31,7.63 47.9,7.04 47.9,6.55 48.08,6.37 48.08,5.68 47.44,5.03 47.15,5.03 47.01,5.18 46.32,5.18 45.51,5.99 45.51,6.76 45.2,7.07 44.89,7.07 44.7,6.87 v2(44.18,6.87)
UART_SCP_TX_SERVO_RX: length 110.6
  TOP w0.089: U1001.K3 81.32,40.48 79.26,40.48 78.73,41 v2(78.6,41)
  IN1 w0.076: v2(35.91,14.55) 36.23,14.23 36.23,8.48 34.07,6.32 34.07,3.89 34.46,3.49 44.36,3.49 44.43,3.56 v1(44.43,3.94)
  IN2 w0.058: v3(32.8,34.65) 32.75,34.7 32.75,40.22 34.95,42.42 36.11,42.42 37.63,43.94 38.57,43.94 39.15,44.52 41.66,44.52 42.37,45.24 45.36,45.24 45.45,45.33 52.72,45.33 53.12,44.93 55.43,44.93 56.58,46.08 59.49,46.08 60.35,46.95 63.7,46.95 65.2,48.45 65.91,48.45 66.74,49.29 66.74,49.49 67.4,50.15 68.41,50.15 68.71,49.85 73.68,49.85 75.34,48.19 75.34,47.07 75.61,46.81 75.61,43.58 77.19,42 77.75,42 78.6,41.15 v2(78.6,41) ; v3(35.9,14.92) 35.91,14.9 v2(35.91,14.55)
  IN4 w0.058: v3(35.9,14.92) 34.82,16 34.82,23.54 36.15,24.87 36.15,28.6 34.01,30.75 34.01,32.31 33.24,33.08 33.24,34.22 v3(32.8,34.65)
