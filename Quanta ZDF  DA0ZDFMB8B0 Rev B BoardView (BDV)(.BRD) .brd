# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART_SERVO_TX_H1_RX: length 29.1
  TOP w0.089: R90407.2 58.07,19.06 57.67,18.65 57.23,18.65 v2(56.98,18.41)
  IN2 w0.058: v2(45.07,6.76) 45.3,6.53 45.3,5.9 46.23,4.97 46.92,4.97 47.06,4.82 47.53,4.82 48.29,5.59 48.29,6.51 48.12,6.69 48.12,7.12 47.52,7.71 47.52,12.18 47.81,12.47 47.81,13.52 48.34,14.05 48.34,15.7 49.69,17.05 49.69,17.25 51.06,18.62 51.88,18.62 52.15,18.9 52.33,18.9 52.65,19.22 53.39,19.22 53.48,19.31 53.78,19.31 53.86,19.23 54.16,19.23 54.82,18.57 55.13,18.57 55.26,18.71 55.61,18.71 55.92,18.41 v2(56.98,18.41)
UART_SERVO_TX_SCP_RX: length 112
  TOP w0.089: U1001.L3 81.12,40.27 80.38,40.27 80.34,40.23 79.16,40.23 78.72,40.67 78.37,40.67 78.19,40.85 v2(78.19,41.03)
  IN1 w0.076: v1(45.45,3.94) 45.2,3.94 44.47,3.21 34.35,3.21 33.84,3.72 33.84,6.42 36,8.58 36,13.82 35.49,14.33 v2(35.49,14.64)
  IN2 w0.058: v3(32.85,34.02) 33.18,34.35 33.18,34.9 32.98,35.11 32.98,40.15 35.04,42.21 36.2,42.21 37.72,43.73 38.66,43.73 39.24,44.31 41.75,44.31 42.46,45.03 45.45,45.03 45.54,45.12 52.63,45.12 53.04,44.72 55.52,44.72 56.67,45.87 59.57,45.87 60.44,46.73 63.78,46.73 65.29,48.24 66,48.24 66.96,49.2 66.96,49.4 67.49,49.94 68.33,49.94 68.63,49.64 73.6,49.64 75.13,48.1 75.13,46.98 75.4,46.72 75.4,43.5 77.1,41.79 77.66,41.79 78.19,41.26 v2(78.19,41.03) ; v2(35.49,14.64) 35.26,14.87 v3(35.26,14.94)
  IN4 w0.058: v3(32.85,34.02) 32.85,33.14 33.8,32.19 33.8,30.66 35.94,28.52 35.94,24.96 34.61,23.63 34.61,15.6 v3(35.26,14.94)
USB2_A0_N: length 127.3
  TOP w0.091: U6546.6 65.24,27.07 65.16,27 64.83,27 64.28,26.45 64.28,23.06 64.02,22.79 64.02,20.63 65.45,19.2 74.06,19.2 74.87,18.38 74.87,11.59 74.26,10.98 74.26,10.21 v2(74.24,10.19)
  IN2 w0.069: v2(74.24,10.19) v3(74,9.76)
  IN3 w0.112: v3(74,9.76) 74.19,9.56 74.19,9.13 74.63,8.69 75.75,8.69 76.78,9.72 85.11,9.72 88.49,6.34 115.05,6.34 115.79,7.08 121.15,7.08 121.53,7.46 139.77,7.46 140.8,8.49 140.8,9.68 143.98,12.86 143.98,28.02 145.15,29.2 145.15,29.74 145.75,30.34 145.75,31.22 v3(145.98,31.45)
  IN4 w0.069: v3(145.98,31.45) v5(145.65,31.45)
  BOTTOM w0.091: J17.13 145.65,31.45 v5(145.65,31.45)
USB2_A0_P: length 127.3
  TOP w0.091: v2(74.7,10.19) 74.51,10.38 74.51,10.88 75.12,11.49 75.12,18.48 74.16,19.44 65.55,19.44 64.26,20.73 64.26,22.69 64.52,22.95 64.52,26.35 64.93,26.76 65.13,26.76 65.31,26.57 U6546.7
  IN2 w0.069: v3(74.6,9.86) 74.52,9.94 74.52,10.02 v2(74.7,10.19)
  IN3 w0.112: v3(74.6,9.86) 74.46,9.72 74.46,9.24 74.74,8.96 75.64,8.96 76.67,9.99 85.22,9.99 88.6,6.61 114.94,6.61 115.68,7.34 121.04,7.34 121.42,7.73 139.66,7.73 140.54,8.6 140.54,9.79 143.71,12.97 143.71,28.13 144.89,29.31 144.89,29.85 145.49,30.45 145.49,31.62 v3(145.96,32.09)
  IN4 w0.069: v5(145.65,31.96) 145.74,31.87 145.85,31.87 145.96,31.97 v3(145.96,32.09)
  BOTTOM w0.091: J17.12 148.39,31.95 148.13,31.69 145.87,31.69 145.65,31.91 v5(145.65,31.96)
USB2_DM: length 141.4
  TOP w0.06: U1001.F26 90.61,41.93 90.61,41.83 90.64,41.8 90.76,41.8 90.88,41.68 91.85,41.68 92.04,41.88
  TOP w0.091: v2(62.44,24.59) 62.53,24.68 62.53,25.55 62.61,25.63 62.61,27.93 62.34,28.2 62.34,29.01 62.67,29.35 63.06,29.35 R91300.1 ; 92.04,41.88 93.14,41.88 93.66,42.4 94.08,42.4 94.27,42.59 v2(94.27,42.71)
  IN2 w0.069: v2(94.27,42.71) 94.27,42.81 94.5,43.03 94.95,43.03 96.77,44.86 97.01,44.86 97.4,45.25 97.4,46.17 97.78,46.55 97.78,47.49 98.94,48.64 98.94,50.6 99.76,51.42 102.66,51.42 104.04,52.8 110.57,52.8 110.92,53.14 111.57,53.14 111.89,52.82 113.61,52.82 114.35,52.07 114.75,52.07 115.02,51.8 117.3,51.8 117.51,51.59 118.14,51.59 v3(118.3,51.75) ; v3(62.31,24.24) 62.44,24.36 v2(62.44,24.59)
  IN3 w0.112: v3(62.31,24.24) 62.51,24.44 62.51,24.6 62.91,25 63.56,25 64.31,24.25 64.62,24.25 65.49,25.12 69.5,25.12 75.92,18.7 75.92,15.99 76.02,15.9 76.02,14.83 76.16,14.68 87.5,14.68 88.63,13.55 91.9,13.55 92.09,13.75 95.87,13.75 96.26,13.35 101.92,13.35 102.59,14.03 110.53,14.03 112.94,16.44 113.06,16.44 115.72,19.1 115.72,22.37 116.48,23.13 116.48,26.85 117.38,27.76 117.38,30.38 118.01,31 118.01,39.61 119.51,41.11 119.51,45.72 119.25,45.97 119.25,47.72 118.21,48.77 118.21,50.16 117.56,50.82 117.56,51.22 117.89,51.55 118.1,51.55 v3(118.3,51.75)
USB2_DM_R: length 2.4
  TOP w0.091: R91300.2 63.95,29.25 64.3,29.25 64.51,29.47 65.14,29.47 65.24,29.57 U6546.1
USB2_DP: length 141.4
  TOP w0.075: 92.06,41.63 91.97,41.55 90.65,41.55 U1001.G26
  TOP w0.091: 92.06,41.63 93.24,41.63 93.76,42.16 94.18,42.16 94.65,42.63 94.65,42.68 v2(94.67,42.7) ; v2(62.87,24.57) 62.77,24.67 62.77,25.45 62.85,25.53 62.85,28.03 62.58,28.3 62.58,28.91 62.77,29.11 63.14,29.11 63.23,29.01 R91301.1
  IN2 w0.069: v3(118.3,51.11) 118.05,51.36 117.41,51.36 117.2,51.57 114.92,51.57 114.65,51.84 114.26,51.84 113.51,52.58 111.79,52.58 111.47,52.91 111.01,52.91 110.67,52.56 104.14,52.56 102.76,51.18 99.85,51.18 99.17,50.5 99.17,48.54 98.01,47.39 98.01,46.45 97.63,46.07 97.63,45.16 97.11,44.63 96.87,44.63 94.95,42.7 v2(94.67,42.7) ; v2(62.87,24.57) 62.87,24.4 63.01,24.26 v3(63.25,24.26)
  IN3 w0.112: v3(63.25,24.26) 63.25,24.11 63.13,23.98 62.95,23.98 62.78,24.16 62.78,24.49 63.02,24.74 63.45,24.74 64.2,23.98 64.73,23.98 65.6,24.86 69.39,24.86 75.66,18.59 75.66,15.88 75.75,15.79 75.75,14.72 76.05,14.42 87.39,14.42 88.52,13.29 92.01,13.29 92.2,13.48 95.76,13.48 96.15,13.09 102.03,13.09 102.7,13.76 110.64,13.76 113.05,16.18 113.17,16.18 115.98,18.99 115.98,22.26 116.74,23.02 116.74,26.74 117.65,27.65 117.65,30.27 118.27,30.89 118.27,39.5 119.77,41 119.77,45.83 119.52,46.08 119.52,47.83 118.47,48.88 118.47,50.27 117.82,50.92 117.82,51.11 118,51.29 118.12,51.29 v3(118.3,51.11)
USB2_DP_R: length 2.4
  TOP w0.091: U6546.2 65.35,29.07 65.2,29.23 64.61,29.23 64.4,29.01 63.89,29.01 R91301.2
USB2_HUB_P1_N: length 68
  TOP w0.091: U6546.3 65.14,28.57 65.01,28.44 64.32,28.44 63.34,27.46 63.34,26.63 63.52,26.45 63.52,24.11 63.29,23.88 63.29,23.54 v2(63.2,23.45) ; U6555.2 21.01,41.84 20.85,41.68 20.85,41.51 20.97,41.38 21.28,41.38 21.65,41.75 22.12,41.75 v2(22.21,41.84)
  IN2 w0.069: v2(63.2,23.45) 63.18,23.43 v3(63.18,23.07) ; v3(25.18,40.77) 25.18,40.62 25.08,40.52 24.09,40.52 22.96,41.64 22.41,41.64 v2(22.21,41.84)
  IN3 w0.112: v3(25.18,40.77) 25.21,40.77 25.58,40.4 25.75,40.4 27.2,38.94 29.12,38.94 29.5,39.33 31.05,39.33 34.51,35.87 38.51,35.87 40,34.38 40,31.69 42.59,29.09 42.59,27.01 44.79,24.81 44.79,21.47 45.11,21.15 45.54,21.15 45.98,20.71 49.13,20.71 49.41,20.99 49.41,21.67 50.05,22.31 52.6,22.31 53.3,21.62 56.38,21.62 56.69,21.3 60.57,21.3 61.75,22.49 63.31,22.49 63.43,22.61 63.43,22.82 v3(63.18,23.07)
USB2_HUB_P1_P: length 68.1
  TOP w0.091: U6546.4 65.14,28.07 65.01,28.2 64.43,28.2 63.58,27.36 63.58,26.73 63.76,26.55 63.76,24.01 63.53,23.78 63.53,23.49 v2(63.61,23.41) ; U6555.1 20.61,41.41 20.87,41.14 21.38,41.14 21.75,41.51 22.08,41.51 v2(22.18,41.41)
  IN2 w0.069: v2(63.61,23.41) 63.83,23.19 63.83,23.08 v3(63.84,23.07) ; v2(22.18,41.41) 22.87,41.41 23.99,40.29 25.03,40.29 v3(25.18,40.14)
  IN3 w0.112: v3(25.18,40.14) 25.64,40.14 27.1,38.68 29.23,38.68 29.61,39.06 30.94,39.06 34.4,35.6 38.4,35.6 39.73,34.27 39.73,31.58 42.33,28.98 42.33,26.9 44.52,24.71 44.52,21.36 45,20.88 45.43,20.88 45.87,20.45 49.24,20.45 49.68,20.88 49.68,21.56 50.16,22.04 52.5,22.04 53.19,21.35 56.27,21.35 56.58,21.04 60.68,21.04 61.86,22.22 63.41,22.22 63.7,22.5 63.7,22.93 v3(63.84,23.07)
USB2_HUB_P3_N: length 49.6
  TOP w0.091: U6546.12 68.94,24.93 69.19,24.67 69.19,24.44 69.07,24.31 v2(69.07,24.21)
  IN2 w0.069: v3(68.73,24.12) 68.98,24.12 v2(69.07,24.21)
  IN3 w0.112: v3(68.73,24.12) 68.73,23.98 68.64,23.89 65.51,23.89 64.95,23.33 64.95,22.42 64.14,21.61 62.03,21.61 60.66,20.23 56.61,20.23 56.01,20.83 50.43,20.83 49.51,19.91 44.97,19.91 43.98,20.9 43.98,24.51 41.37,27.12 41.37,29.2 39.19,31.38 39.19,34.04 38.65,34.59 38.28,34.59 v3(38.11,34.75)
  IN4 w0.069: v3(38.11,34.75) 38.11,34.63 38.21,34.52 38.51,34.52 38.61,34.62 38.61,34.72 v5(38.53,34.79)
  BOTTOM w0.091: J15.10 38.55,35.38 38.97,34.96 38.97,34.66 38.81,34.5 38.61,34.5 38.53,34.58 v5(38.53,34.79)
USB2_HUB_P3_P: length 49.7
  TOP w0.091: U6546.13 69.44,24.41 69.48,24.36 v2(69.48,24.21)
  IN2 w0.069: v2(69.48,24.21) 69.48,23.93 v3(69.38,23.83)
  IN3 w0.112: v3(69.38,23.83) 69.17,23.63 65.62,23.63 65.21,23.22 65.21,22.31 64.24,21.34 62.14,21.34 60.76,19.97 56.5,19.97 55.9,20.57 50.54,20.57 49.61,19.65 44.86,19.65 43.71,20.79 43.71,24.4 41.11,27.01 41.11,29.09 38.93,31.27 38.93,33.93 38.54,34.32 38.29,34.32 v3(38.11,34.14)
  IN4 w0.069: v3(38.11,34.14) 38.16,34.19 v5(38.51,34.19)
  BOTTOM w0.091: v5(38.51,34.19) 38.58,34.26 38.91,34.26 39.21,34.56 39.21,35.06 39.05,35.22 J15.11
USB2_HUB_P4_N: length 113.9
  TOP w0.091: U6546.15 71.48,26.57 71.64,26.42 71.64,23.86 v2(71.43,23.65)
  IN2 w0.069: v3(70.15,21.62) 70.34,21.81 70.34,22.41 70.83,22.9 71.29,22.9 71.74,23.35 71.74,23.58 71.66,23.65 v2(71.43,23.65)
  IN3 w0.112: v3(70.15,21.62) 70.33,21.44 70.33,21.2 70.67,20.86 72.26,20.86 74.88,18.24 74.88,14.12 75.36,13.64 87.07,13.64 88.2,12.5 90.9,12.5 92.44,10.96 98.18,10.96 99.46,12.24 102.86,12.24 103.6,12.98 110.99,12.98 113.27,15.26 114.27,15.26 116.86,17.85 116.86,21.95 117.53,22.62 117.53,26.42 118.48,27.38 118.48,29.42 119.05,29.99 119.05,39.17 120.56,40.68 120.56,46.21 120.3,46.47 120.3,48.19 119.29,49.21 119.29,52.4 117.85,53.84 117.85,55.07 116.17,56.75 116.17,57.55 113.43,60.29 113.43,61.2 v6(113.65,61.42)
  BOTTOM w0.091: L12.3 114.76,61.28 114.61,61.43 114.32,61.43 113.81,61.93 113.56,61.93 113.41,61.79 113.41,61.66 v6(113.65,61.42)
USB2_HUB_P4_P: length 113.9
  TOP w0.091: U6546.16 71.54,27.07 71.88,26.74 71.88,23.86 v2(72.08,23.65)
  IN2 w0.069: v3(70.76,21.62) 70.57,21.81 70.57,22.31 70.92,22.66 71.38,22.66 71.97,23.25 71.97,23.54 v2(72.08,23.65)
  IN3 w0.112: v6(112.94,61.42) 113.17,61.19 113.17,60.18 115.91,57.44 115.91,56.64 117.58,54.96 117.58,53.73 119.02,52.29 119.02,49.1 120.03,48.09 120.03,46.36 120.29,46.1 120.29,40.79 118.79,39.28 118.79,30.1 118.22,29.53 118.22,27.49 117.27,26.53 117.27,22.73 116.59,22.06 116.59,17.96 114.16,15.52 113.16,15.52 110.88,13.24 103.5,13.24 102.75,12.5 99.35,12.5 98.07,11.23 92.55,11.23 91.01,12.77 88.31,12.77 87.17,13.9 75.47,13.9 75.14,14.23 75.14,18.35 72.37,21.12 70.78,21.12 70.6,21.3 70.6,21.46 v3(70.76,21.62)
  BOTTOM w0.091: L12.2 114.76,61.83 114.61,61.67 114.42,61.67 113.91,62.17 113.46,62.17 113.17,61.89 113.17,61.66 v6(112.94,61.42)
USB2_WFC_N: length 3.2
  BOTTOM w0.091: L12.4 116.75,61.28 116.91,61.43 117.11,61.43 118.09,62.41 118.09,62.69 118.1,62.71 J20.3
USB2_WFC_P: length 3.2
  BOTTOM w0.091: J20.2 117.3,62.86 117.44,62.72 117.76,62.72 117.84,62.64 117.84,62.51 117.01,61.67 116.91,61.67 116.75,61.83 L12.1
USB_A0_OC_ODL: length 125.3
  TOP w0.089: v2(68.94,31.75) U6546.24
  IN2 w0.058: v2(68.94,31.75) 68.63,31.75 68.57,31.81 v3(68.57,31.84)
  IN3 w0.102: v3(138.03,40.77) 137.9,40.77 137.57,41.1 137.02,41.1 136.94,41.03 134.98,41.03 131.66,44.35 131.66,46.25 131.07,46.84 130.7,46.84 129.87,47.68 129.87,54.51 127.53,56.85 126.59,56.85 124.19,59.25 124.19,61.88 121.14,64.93 121.14,66.11 120.62,66.63 76.22,66.63 71.94,62.34 71.57,62.34 67.78,58.55 67.78,54.18 65.01,51.41 65.01,49.21 65.13,49.08 65.13,46.54 65.44,46.23 65.97,46.23 66.21,46 66.21,44.01 66.99,43.23 66.99,42.2 66.78,41.99 66.78,40.6 66.66,40.47 66.66,37.47 67.04,37.09 67.04,36.63 66.66,36.25 66.66,35.79 67.75,34.7 68.49,34.7 68.82,34.37 68.82,33.69 68.56,33.43 68.56,31.84 v3(68.57,31.84)
  IN4 w0.058: v3(138.03,40.77) v5(138.03,40.39)
  BOTTOM w0.089: R91331.1 138.13,40.29 v5(138.03,40.39)
USB_A0_OC_ODL_R: length 1.4
  BOTTOM w0.089: U6552.3 138.41,41.54 138.79,41.15 R91331.2
USB_C0_CC1: length 123.7
  TOP w0.254: CON7101.A5 8.77,56.95
  TOP w0.381: v1(17.23,51.26) 17.23,51.72 17.02,51.93 D2743.1 16.49,51.59 16.21,51.31 14.85,51.31 14.6,51.06 12.33,51.06 11.34,52.05 11.34,55.15 11.16,55.32 11.16,55.56 10.66,56.07 9.86,56.07 9.47,56.46 C10448.2 9.18,56.95 8.77,56.95 ; v2(37.27,8) 38.17,8 38.56,8.38 39.44,8.38 39.56,8.26 41.82,8.26 42.04,8.48 48.33,8.48 48.45,8.36 49.54,8.36 49.7,8.19 v2(54.52,8.19) ; v2(55.47,8.77) 55.61,8.92 55.61,10.04 56.3,10.73 60.2,10.73 60.77,10.17 Q762.3
  IN1 w0.381: v2(23.84,44.69) 23.55,44.97 23.55,45.42 21.73,47.25 20.02,47.25 19.41,47.86 19.41,48.68 17.23,50.86 v1(17.23,51.26)
  IN2 w0.381: v2(54.52,8.19) 54.89,8.19 v2(55.47,8.77) ; v2(37.27,8) 36.01,9.26 32.88,9.26 30.7,11.43 30.11,11.43 29.66,11.88 21.14,11.88 20.74,11.47 16.71,11.47 14.81,13.37 14.81,18.26 14.52,18.55 14.52,19.65 17.02,22.15 17.02,24.35 16.9,24.47 16.9,26.4 16.76,26.55 16.76,27.7 16.71,27.75 16.71,28.37 16.29,28.79 15.98,28.79 15.69,29.08 15.69,30.4 15.31,30.78 15.31,31.79 15.47,31.95 15.47,32.27 15.96,32.77 15.96,33.45 15.74,33.67 15.74,34.4 16.15,34.8 16.42,34.8 18.48,36.86 18.48,38.03 17.48,39.03 17.48,41.66 17.77,41.95 17.77,42 18.25,42.48 18.65,42.48 19.23,43.06 22.21,43.06 v2(23.84,44.69) 23.86,44.71 23.99,44.71 24.33,44.36 v3(25.41,44.36)
  IN4 w0.381: v3(25.41,44.36) 25.68,44.1 v5(26.04,44.1)
  BOTTOM w0.254: R91328.2 25.05,40.97 24.96,40.88 U6582.A1
  BOTTOM w0.381: R91328.2 25.76,40.97 26.04,41.26 26.04,42.47 26.2,42.63 26.2,43.94 v5(26.04,44.1)
USB_C0_CC1_U: length 7.8
  TOP w0.254: v6(26.86,44.68) 26.81,44.73 U6533.C1
  BOTTOM w0.254: R91328.1 24.08,40.52 23.86,40.75 U6582.B1
  BOTTOM w0.381: v6(26.86,44.68) 26.73,44.56 26.73,42.41 26.58,42.25 26.58,41.03 26.06,40.52 R91328.1
USB_C0_CC2: length 148.4
  TOP w0.381: Q763.3 57.42,9.42 57.69,9.7 59.1,9.7 59.12,9.7 59.13,9.69 59.25,9.57 59.27,9.57 59.31,9.53 59.31,7.44 60.58,6.18 60.58,4.36 61.55,3.38 v2(61.55,2.63)
  IN2 w0.381: v6(17.36,44.15) 17.65,44.44 18.32,44.44 18.39,44.37 22.47,44.37 23.55,45.45 24.39,45.45 v6(24.63,45.21) ; v3(60.89,2.47) 61.39,2.47 v2(61.55,2.63)
  IN3 w0.381: v3(60.89,2.47) 59.17,2.47 58.8,2.1 19.45,2.1 17.94,3.61 v6(16.82,3.61)
  BOTTOM w0.152: CON7101.B5 5.99,55.33
  BOTTOM w0.178: 5.99,55.33 7.23,55.33 7.33,55.23
  BOTTOM w0.254: U6582.A3 24.52,41.68 25.66,42.82 R91329.2
  BOTTOM w0.381: 7.33,55.23 7.6,54.97 7.6,53.79 8.67,52.71 C10449.2 8.67,51.46 9.55,50.58 D2742.1 9.97,50.3 10.62,49.65 14.48,49.65 17.36,46.77 v6(17.36,44.15) 16.32,44.15 15.76,43.58 15.76,42.25 16.09,41.92 16.09,39.53 14.43,37.88 12.25,37.88 11.54,37.17 4.81,37.17 4.43,36.78 4.43,23.39 5.12,22.7 10.87,22.7 11.94,21.62 11.94,13.64 16.72,8.86 16.72,3.71 v6(16.82,3.61) ; v6(24.63,45.21) 24.63,44.75 25.66,43.72 R91329.2
USB_C0_CC2_U: length 3.4
  IN2 w0.381: v2(26.04,43.9) 25.66,43.52 v3(25.41,43.52)
  IN4 w0.381: v3(25.41,43.52) 25.21,43.32 v5(25.21,43.11)
  BOTTOM w0.254: U6582.B3 23.86,41.87 24.06,42.07 24.33,42.07 25.21,42.94 v5(25.21,43.11)
USB_C0_DISCHARGE: length 121.2
  TOP w0.089: Q790.2 27.97,48.19 R91245.2 28.6,48.82 59,48.82 60.16,49.99 v2(65.85,49.99)
  IN2 w0.058: v3(126.5,50.32) 126.34,50.16 v2(126.34,49.92) ; v3(65.77,49.54) 65.77,49.86 65.85,49.94 v2(65.85,49.99)
  IN3 w0.102: v3(65.77,49.54) 65.77,49.76 66.72,50.72 67.41,50.72 68.13,51.44 68.13,52.91 69.38,54.16 69.38,58.64 71.29,60.56 72.42,60.56 76.86,65 116.19,65 120.19,61 120.19,59.79 121.21,58.77 122.41,58.77 123.35,57.82 123.35,56.08 124.21,55.21 124.94,55.21 125.97,54.18 125.97,50.81 126.34,50.44 126.39,50.44 v3(126.5,50.32)
USB_C0_HPD_OD: length 163.1
  TOP w0.089: R10.2 v2(23.89,29.62) ; U6517.D1 127.56,49.92 128.15,49.33 v2(128.15,49.03)
  IN2 w0.058: v2(23.89,29.62) 23.89,29.73 24.21,30.05 24.49,30.05 24.9,30.46 25.26,30.46 25.61,30.11 28.98,30.11 29.83,30.97 29.83,31.7 31.37,33.24 32.86,33.24 33.4,33.77 33.4,35.1 33.21,35.29 33.21,40.08 35.13,42 36.29,42 37.81,43.52 38.75,43.52 39.33,44.1 41.83,44.1 42.55,44.81 46.85,44.81 47.16,44.51 55.61,44.51 56.76,45.66 59.66,45.66 60.53,46.52 63.87,46.52 65.18,47.83 v3(65.85,47.83) 65.9,47.83 67.17,49.1 67.17,49.31 67.58,49.73 68.24,49.73 68.54,49.43 73.51,49.43 74.92,48.02 74.92,46.9 75.19,46.63 75.19,43.41 77.96,40.63 77.96,40.52 v2(79.22,39.26) ; v2(128.15,49.03) 128.15,49.38 127.62,49.92 v3(127.11,49.92)
  IN3 w0.102: v3(65.85,47.83) 65.85,48.81 65.31,49.35 65.31,49.74 66.59,51.02 67.28,51.02 67.83,51.57 67.83,53.04 69.07,54.29 69.07,58.77 71.17,60.87 72.29,60.87 76.73,65.31 116.31,65.31 120.53,61.09 120.53,59.88 121.34,59.07 122.53,59.07 126.37,55.23 126.37,51.11 127.11,50.37 v3(127.11,49.92)
USB_C0_PD_INT_ODL: length 127.1
  TOP w0.089: U6517.G5 125.08,51.68 125.08,52.6 125.27,52.79 125.27,54.1 124.58,54.78 124.58,55.37 124.42,55.53 124.42,56.8 123.69,57.53 R90605.2 124.14,57.99 124.14,60.13 124.32,60.31 v2(124.32,62.52)
  IN2 w0.058: v2(124.32,62.52) 124.06,62.77 122.59,62.77 122.56,62.79 120.89,62.79 120.23,63.46 118.09,63.46 116.93,64.62 77.69,64.62 76.18,63.12 76.18,62.11 73.67,59.6 73.67,52.34 72.53,51.2 71.8,51.2 71.46,50.86 69.19,50.86 68.59,51.47 66.27,51.47 64.28,49.48 63.41,49.48 62.67,48.73 60.63,48.73 59.3,47.4 58.11,47.4 57.98,47.28 56.88,47.28 56.2,46.59 55,46.59 54.31,47.28 53.48,47.28 52.7,46.5 51.27,46.5 50.5,47.27 43.3,47.27 42.74,46.71 40.14,46.71 39.12,45.69 38.47,45.69 38.03,45.25 34.75,45.25 34.54,45.46 28.42,45.46 28.3,45.35 28.3,44.56 27.01,43.26 27.01,42.57 v2(26.98,42.54)
USB_C0_RX1_C_N: length 5.2
  TOP w0.071: U93.32 22.89,31 23.05,30.84 23.13,30.84 23.51,31.21 23.51,32.36 23.94,32.79 23.94,33.17 R91284.2 23.94,33.64 23.94,34.24 23.89,34.29 C10653.1
USB_C0_RX1_C_P: length 5.2
  TOP w0.071: U93.31 22.95,30.6 22.97,30.61 23.22,30.61 23.73,31.12 23.73,32.26 24.16,32.7 24.16,33.3 R91283.2 24.16,33.51 24.16,34.14 24.31,34.29 C10652.1
USB_C0_RX1_N: length 37
  TOP w0.071: v2(16.21,53.5) 16.13,53.58 15.18,53.58 15.1,53.5 14.59,53.5 14.4,53.31 U3.4 v2(13.13,53.31) ; C10653.2 23.89,35.48 23.89,36.98 23.56,37.31 23.56,37.77 23.32,38.01 v2(23.22,38.01)
  IN2 w0.056: v2(13.13,53.31) 12.89,53.56 12.83,53.56 12.63,53.76 12.63,54.92 10.79,56.75 10.79,56.96 10.33,57.42 10.33,57.79 9.7,58.43 8.75,58.43 8.47,58.15 6.1,58.15 5.92,57.96 CON7101.B10 ; v3(16.52,53.3) v2(16.21,53.5) ; v2(23.22,38.01) v3(23.22,38.34)
  IN3 w0.089: v3(23.22,38.34) 23.49,38.6 23.49,38.87 22.56,39.8 22.56,45.49 22.07,45.98 21.72,45.98 21.24,46.46 20.4,46.46 18.99,47.86 18.99,48.98 16.87,51.1 16.87,53.26 16.74,53.4 16.62,53.4 v3(16.52,53.3)
USB_C0_RX1_P: length 37
  TOP w0.071: C10652.2 24.11,35.45 24.11,37.08 23.78,37.41 23.78,37.81 v2(23.99,38.01) ; v2(13.13,53.81) U3.5 14.43,53.81 14.51,53.73 15.01,53.73 15.08,53.8 16.09,53.8 v2(16.19,53.9)
  IN2 w0.056: v2(23.99,38.01) v3(23.99,38.34) ; v3(16.52,53.9) v2(16.19,53.9) ; v2(13.13,53.81) 13.09,53.76 12.91,53.76 12.83,53.85 12.83,55 10.99,56.84 10.99,57.04 10.54,57.5 10.54,57.87 9.78,58.63 8.67,58.63 8.39,58.35 6.17,58.35 CON7101.B11
  IN3 w0.089: v3(16.52,53.9) 16.57,53.9 17.12,53.36 17.12,51.2 19.24,49.08 19.24,47.96 20.5,46.7 21.34,46.7 21.82,46.22 22.17,46.22 22.8,45.59 22.8,39.9 23.73,38.97 23.73,38.59 v3(23.99,38.34)
USB_C0_RX2_C_N: length 5.4
  TOP w0.071: C10708.1 18.88,36.37 19.05,36.2 19.05,35.61 R91290.2 19.06,35.25 19.06,34.97 19.72,34.3 19.72,32.48 19.79,32.41 19.79,32.31 19.7,32.22 U93.6
USB_C0_RX2_C_P: length 5.4
  TOP w0.071: C10707.1 19.44,36.37 19.27,36.2 19.27,35.61 R91289.2 19.29,35.28 19.29,35.06 19.95,34.4 19.95,32.57 20.01,32.5 20.01,32.32 20.1,32.24 U93.5
USB_C0_RX2_N: length 27.3
  TOP w0.071: CON7101.A10 8.53,54.45 8.75,54.23 8.91,54.23 9.04,54.1 9.2,54.1 9.39,54.3 U2.1 v2(10.63,54.3) ; v2(18.52,39.41) 18.78,39.15 18.78,38.3 19.05,38.03 19.05,37.52 C10708.2
  IN2 w0.056: v2(10.63,54.3) 10.63,54.18 10.7,54.11 10.9,54.11 11.14,53.87 11.14,53.48 12.91,51.7 12.91,51.34 13.17,51.09 v3(13.22,51.09) ; v3(18.52,39.07) v2(18.52,39.41)
  IN3 w0.089: v3(18.52,39.07) 18.7,39.07 18.84,39.21 18.84,39.56 19.07,39.79 19.36,39.79 19.55,39.98 19.55,43.91 16.84,46.63 16.84,48.6 14.87,50.56 14.54,50.56 13.48,51.62 13.12,51.62 13.02,51.51 13.02,51.29 v3(13.22,51.09)
USB_C0_RX2_P: length 27.3
  TOP w0.071: v2(10.63,53.8) U2.2 9.41,53.8 9.33,53.88 8.95,53.88 8.82,54.01 8.67,54.01 8.61,53.95 CON7101.A11 ; v2(19.29,39.41) 19,39.12 19,38.39 19.27,38.12 19.27,37.52 C10707.2
  IN2 w0.056: v3(12.61,51.09) 12.71,51.19 12.71,51.62 10.94,53.39 10.94,53.79 10.82,53.9 10.74,53.9 v2(10.63,53.8) ; v3(19.29,39.07) v2(19.29,39.41)
  IN3 w0.089: v3(19.29,39.07) 19.08,39.27 19.08,39.46 19.17,39.55 19.46,39.55 19.79,39.88 19.79,44.01 17.08,46.73 17.08,48.7 14.97,50.81 14.64,50.81 13.58,51.86 13.02,51.86 12.77,51.61 12.77,51.25 v3(12.61,51.09)
USB_C0_SBU1: length 10.9
  IN2 w0.056: v2(7.93,55.45) 7.93,55.7 v3(8.04,55.81)
  IN4 w0.056: v3(8.04,55.81) v5(8.04,56.16)
  BOTTOM w0.071: v5(8.04,56.16) 7.56,56.16 7.44,56.28 7.44,56.71 7.51,56.78 8.07,56.78 8.49,56.36 8.49,56.01 8.29,55.82 8.29,54.61 8.5,54.4 8.91,54.4 R90742.1 9.23,54.4 9.4,54.4 9.8,54.01 10.6,54.01 10.8,53.81 10.8,53.36 D2740.1 10.88,52.36 10.88,52.21 10.75,52.07 R90810.1 10.75,51.38 R90744.2
USB_C0_SBU1_MUX: length 3
  IN2 w0.056: v3(16.9,31.82) 16.87,31.79 v2(16.87,31.47)
  IN4 w0.056: v5(16.01,29.83) 15.91,29.93 15.91,30.59 16.03,30.71 16.36,30.71 16.65,31 16.65,31.63 16.83,31.82 v3(16.9,31.82)
USB_C0_SBU1_MUX_R: length 2.3
  TOP w0.089: U93.10 17.61,30.6 17.45,30.44 16.76,30.44 16.62,30.57 16.62,30.77 R91292.2
USB_C0_SBU2: length 11
  BOTTOM w0.071: CON7101.B8 6,57.08 7.27,57.08 7.35,57 8.16,57 8.71,56.45 8.71,55.92 8.52,55.72 8.52,54.7 8.59,54.63 8.91,54.63 R90743.1 9.23,54.63 9.5,54.63 9.89,54.24 10.69,54.24 11.02,53.9 11.02,53.39 D1.1 11.11,52.51 11.11,52.23 11.31,52.03 R90811.1 11.31,51.38 R90745.2
USB_C0_SBU2_MUX: length 3
  IN2 w0.056: v3(16.29,31.82) 16.11,31.64 v2(16.11,31.47)
  IN4 w0.056: v3(16.29,31.82) 16.44,31.67 16.44,31.09 16.27,30.92 15.96,30.92 15.88,30.99 15.88,32.01 v5(15.98,32.11)
USB_C0_SBU2_MUX_R: length 2.6
  TOP w0.089: R91291.2 16.38,30.76 16.38,30.47 16.66,30.2 U93.11
USB_C0_TX1_C_N: length 6.6
  TOP w0.071: U93.2 21.3,32.25 21.39,32.34 21.39,32.51 22.11,33.23 22.11,35.41 21.85,35.67 21.85,36.65 R91286.2 21.84,37.01 21.84,37.46 21.8,37.5 C10649.1
USB_C0_TX1_C_P: length 6.6
  TOP w0.071: U93.1 21.7,32.24 21.61,32.32 21.61,32.42 22.33,33.14 22.33,35.5 22.08,35.76 22.08,36.68 R91285.2 22.07,37.01 22.07,37.46 22.11,37.5 C10656.1
USB_C0_TX1_N: length 30.4
  TOP w0.071: CON7101.A3 8.52,57.95 8.65,58.08 8.65,58.23 8.84,58.42 9.69,58.42 10.37,57.74 10.37,57.25 11.95,55.67 11.95,52.57 12.71,51.81 U3.10 U3.1 14.36,51.81 14.71,52.16 15.34,52.16 v2(15.45,52.05)
  IN2 w0.056: v3(15.81,52.07) v2(15.45,52.05) ; v2(21.67,37.98) v3(21.67,38.31)
  IN3 w0.089: v3(15.81,52.07) 16,52.27 16.17,52.27 16.28,52.15 16.28,50.86 18.25,48.89 18.25,47.79 21.89,44.14 21.89,38.52 v3(21.67,38.31)
USB_C0_TX1_P: length 30.4
  TOP w0.071: v2(15.48,52.48) 15.38,52.38 14.61,52.38 14.55,52.31 U3.2 U3.9 12.52,52.31 12.17,52.66 12.17,55.76 10.6,57.34 10.6,57.84 9.79,58.64 8.75,58.64 8.56,58.45 CON7101.A2
  IN2 w0.056: v2(15.48,52.48) v3(15.81,52.68) ; v2(22.31,37.98) v3(22.31,38.31)
  IN3 w0.089: v3(15.81,52.68) 15.98,52.51 16.27,52.51 16.52,52.25 16.52,50.96 18.49,48.99 18.49,47.89 22.13,44.24 22.13,38.48 v3(22.31,38.31)
USB_C0_TX2_C_N: length 3.4
  TOP w0.071: U93.4 20.5,32.38 20.59,32.47 20.59,33 20.94,33.35 20.94,33.75 R91288.2 20.95,34.09 20.95,34.53 20.91,34.58 C10651.1
USB_C0_TX2_C_P: length 3.5
  TOP w0.071: C10650.1 21.22,34.58 21.18,34.53 21.18,34.09 R91287.2 21.17,33.73 21.17,33.25 20.81,32.9 20.81,32.47 20.9,32.38 U93.3
USB_C0_TX2_N: length 31.8
  TOP w0.071: v2(8.96,52.8) 9.1,52.66 9.32,52.66 9.46,52.8 U2.4 v2(10.63,52.8) ; C10651.2 20.95,35.3 20.95,35.49 20.64,35.8 20.64,38.47 20.31,38.8 20.31,39.09 v2(20.2,39.2)
  IN2 w0.056: v2(8.96,52.8) 8.96,52.77 8.87,52.69 8.7,52.69 8.6,52.78 8.6,53.2 7.43,54.36 6.16,54.36 CON7101.B3 ; v3(18.32,40.65) 18.51,40.84 19.27,40.84 20.28,39.83 20.28,39.27 v2(20.2,39.2) ; v3(11.57,51.19) 11.44,51.19 11.32,51.31 11.32,52.41 11.04,52.7 10.73,52.7 v2(10.63,52.8)
  IN3 w0.089: v3(18.32,40.65) 18.52,40.84 18.84,40.84 19.15,41.15 19.15,43.79 17.53,45.41 16.71,45.41 16.47,45.65 16.47,48.38 14.62,50.22 12.53,50.22 v3(11.57,51.19)
USB_C0_TX2_P: length 31.8
  TOP w0.071: v2(20.63,39.22) 20.53,39.12 20.53,38.9 20.86,38.56 20.86,35.9 21.18,35.58 21.18,35.3 C10650.2 ; v2(10.63,52.3) U2.5 9.42,52.3 9.28,52.43 9.09,52.43 v2(8.95,52.3)
  IN2 w0.056: v2(8.95,52.3) 8.76,52.48 8.61,52.48 8.39,52.7 8.39,53.11 7.35,54.16 6.13,54.16 5.92,53.95 CON7101.B2 ; v3(11.51,50.58) 11.51,50.68 11.11,51.08 11.11,52.33 10.95,52.49 10.83,52.49 v2(10.63,52.3) ; v3(18.32,41.28) 18.32,41.2 18.49,41.04 19.36,41.04 20.48,39.92 20.48,39.38 v2(20.63,39.22)
  IN3 w0.089: v3(11.51,50.58) 11.83,50.58 12.43,49.98 14.52,49.98 16.23,48.28 16.23,45.55 16.61,45.17 17.43,45.17 18.91,43.69 18.91,41.25 18.74,41.08 18.52,41.08 v3(18.32,41.28)
USB_C0_USB2_L_N: length 17.4
  TOP w0.091: EMI7101.2 15.51,50.57 15.4,50.68 15.12,50.68 14.99,50.55 14.99,50.2 14.86,50.06 14.71,50.06 14.45,50.32 11.97,50.32 11.34,50.95 11.09,50.95 10.83,51.21 v2(10.67,51.21) ; v2(8.98,55.93) 8.96,55.95 CON7101.A7
  IN2 w0.069: CON7101.B7 6.97,56.6 7.3,56.93 9.23,56.93 9.51,56.65 9.51,56.22 9.28,55.99 9.04,55.99 v2(8.98,55.93) 8.9,55.84 8.9,54.03 9.86,53.07 9.86,51.06 9.93,50.99 10.45,50.99 v2(10.67,51.21)
USB_C0_USB2_L_P: length 17.4
  TOP w0.091: CON7101.A6 8.87,56.45 v2(8.95,56.37) ; EMI7101.3 14.61,49.82 14.35,50.07 11.87,50.07 11.24,50.71 10.99,50.71 10.94,50.76 v2(10.67,50.76)
  IN2 w0.069: v2(10.67,50.76) 9.83,50.76 9.63,50.96 9.63,52.97 8.66,53.94 8.66,56.08 v2(8.95,56.37) 9.1,56.22 9.18,56.22 9.27,56.31 9.27,56.55 9.13,56.69 7.39,56.69 7.32,56.62 7.32,55.87 7.25,55.8 CON7101.B6
USB_C0_USB2_N: length 8.5
  TOP w0.091: U6555.7 21.01,45.04 20.96,45.08 20.96,45.34 20.72,45.59 20.02,45.59 17.74,47.87 17.74,49.89 17.26,50.37 EMI7101.1
USB_C0_USB2_P: length 8.6
  TOP w0.091: U6555.8 20.61,45.03 20.72,45.14 20.72,45.24 20.62,45.35 19.92,45.35 17.5,47.77 17.5,49.79 17.16,50.13 17.01,50.13 16.93,50.04 16.93,49.77 16.85,49.69 16.69,49.69 EMI7101.4
USB_HUB_RESET_L: length 2.1
  TOP w0.089: R91099.2 72.43,27.36 C10454.2 72.12,27.42 71.96,27.57 U6546.17
USBA_POWER_EN: length 1.4
  TOP w0.089: R91206.2 89.79,32.18 90.24,32.63 U1001.AJ25
UVLO_VTH: length 4.3
  IN2 w0.058: v8(108.42,40.45) 108.42,40.51 108.69,40.77 109.66,40.77 110.15,41.26 110.15,41.61 110.28,41.73 110.91,41.73 111.36,41.28 v3(111.36,41.23)
  IN4 w0.058: v3(111.36,41.23) 111.2,41.39 111.19,41.39 v5(111.11,41.47)
VA12_PMU: length 26.1
  TOP w0.15: 87.97,32.26 87.97,32.39 88.07,32.5 88.07,33 U1001.AH20
  TOP w0.203: 109.2,42.04 108.82,41.66 U2001.N16
  TOP w0.305: C1001.2 86.79,31.56 87.12,31.88 87.6,31.88 87.97,32.26
  IN2 w0.18: v8(89.43,43.16) 89.7,43.42 89.7,44.12 90.53,44.95 v2(90.58,44.95)
  IN2 w0.2: v3(94.04,48.04) 93.38,48.04 93.18,47.84 93.18,47.64 90.58,45.05 v2(90.58,44.95) ; v3(80.53,43.33) 80.7,43.16 v8(81.03,43.16)
  IN2 w0.203: 89.06,41.39 89.06,41.19 v8(89.04,41.16)
  IN2 w0.254: v2(86.55,31.51) 86.49,31.46 86.29,31.46 v3(86.19,31.36) ; v8(89.44,37.16) 89.44,37.13 89.73,36.84 90.07,36.84 90.48,36.43 91.02,36.43 91.15,36.56 92.34,36.56 92.59,36.31 92.59,35.95 92.39,35.74 92.39,35.34 v3(92.34,35.29) ; v3(89.42,41.75) 89.06,41.39 ; v8(85.43,35.96) 85.74,35.96 v3(85.77,35.99) ; v2(80.24,37.77) 80.25,37.77 80.45,37.57 v3(80.5,37.57)
  IN4 w0.254: v10(80.81,43.11) 80.78,43.13 80.72,43.13 v3(80.53,43.33) ; v5(89.64,42.04) 89.64,41.97 v3(89.42,41.75)
  BOTTOM w0.254: v5(85.48,35.75) 85.74,36.01 C1010.2
  BOTTOM w0.381: v5(80.96,37.68) 80.81,37.83 C6901.1 80.07,38.47 79.69,38.85 79.69,42.68 80.15,43.14 C5001.2
  vias: v1(111.95,45.12) v1(112.2,45.12) v1(112.2,44.86) v1(112.45,45.12) v1(112.45,44.86) v1(112.45,44.61) v2(111.97,45.8) v2(112.1,46.03) v2(112.23,45.8) v2(112.38,46.03) v2(112.48,45.8) v2(112.63,46.01) v3(112.2,45.45) v3(112.61,45.45) v3(113.01,45.45) v4(92.21,34.5) v4(92.21,34.25) v4(92.29,34.75) v4(92.49,34.93) v4(92.46,34.51) v4(92.46,34.25) v4(92.74,34.93) v4(92.69,34.65) v4(92.69,34.38) v4(94.39,48.04) v4(94.39,47.78) v4(94.67,48.04) v4(94.67,47.78) v4(94.93,48.04) v4(94.93,47.78) v4(112.23,46.06) v4(112.23,45.8) v4(112.48,46.06) v4(112.48,45.8) v4(112.73,46.06) v4(112.73,45.8) v5(92.49,34.93) v5(94.39,48.04) v5(94.39,47.78) v5(94.67,48.04) v5(94.67,47.78) v5(94.93,48.04) v5(94.93,47.78) v5(112.23,46.06) v5(112.23,45.8) v5(112.48,46.06) v5(112.48,45.8) v5(112.73,46.06) v5(112.73,45.8) v7(81.46,36.82)
VAUD28_PMU: length 15.3
  TOP w0.203: R90658.2 108.57,29.52 108.87,29.22 112.89,29.22 113.27,29.6 113.27,32.22 112.75,32.74 112.48,32.74 112.28,32.94 112.28,33.18 112.2,33.25 v1(112.2,33.28) ; v1(111.59,36.05) 110.83,36.05 U2001.R5
  IN1 w0.203: v1(112.2,33.28) 112.33,33.41 112.33,35.82 112.1,36.05 v1(111.59,36.05)
VAUX18_PMU: length 7.7
  IN1 w0.203: v7(108.42,37.65) 108.44,37.65 108.79,37.3 109.39,37.3 111.09,35.6 111.23,35.6 111.97,34.85 111.97,33.99 111.79,33.81 v2(111.77,33.81)
  IN2 w0.203: v3(111.36,34.09) 111.41,34.04 111.54,34.04 v2(111.77,33.81)
  IN4 w0.203: v3(111.36,34.09) 111.41,34.04 v5(111.74,34.04)
  BOTTOM w0.203: v5(111.74,34.04) 111.94,34.04 112.1,34.2 C2108.1
VBIF28_PMU: length 8
  IN2 w0.203: v8(108.42,38.85) 108.11,38.85 v3(108.08,38.87)
  IN4 w0.203: v3(108.08,38.87) 108.47,38.87 108.9,39.3 109.46,39.3 v5(109.74,39.03)
  BOTTOM w0.203: R2301.1 113.43,42.28 112.96,41.81 C2106.1 112.96,40.62 111.97,39.64 111.29,39.64 110.85,39.2 109.91,39.2 v5(109.74,39.03)
VCAMA2_PMU: length 2.5
  IN1 w0.203: v2(109.8,38.74) 109.66,38.87 109.23,38.87 108.85,39.25 v7(108.82,39.25)
  IN2 w0.203: v3(110.58,38.32) 110.16,38.74 v2(109.8,38.74)
  IN4 w0.203: v5(110.91,38.32) v3(110.58,38.32)
VCAMA_PMU: length 7.5
  TOP w0.203: C10483.1 110.5,34.07 v1(110.53,34.09)
  IN1 w0.06: v7(108.42,39.25) 108.22,39.05 108.22,37.14 108.31,37.05 108.61,37.05 108.75,36.92
  IN1 w0.254: 108.75,36.92 109.23,36.92 110.68,35.47 110.68,34.88 110.85,34.71 110.85,34.35 110.6,34.09 v1(110.53,34.09)
VCAMD_PMU: length 1.6
  TOP w0.254: 109.24,42.52 108.42,41.71 U2001.M15
VCAMIO_PMU: length 101.3
  TOP w0.203: R91260.1 72.73,48.64 73.01,48.93 73.01,50.88 71.71,52.18 v2(71.13,52.18)
  IN2 w0.203: v8(105.58,37.7) 105.56,37.7 105.16,37.3 v3(105.09,37.3) ; v3(71.48,52.18) v2(71.13,52.18)
  IN4 w0.203: v3(71.48,52.18) 71.51,52.2 v5(71.81,52.2)
  IN4 w0.254: v3(105.09,37.3) 105.09,37.57 v5(104.75,37.92)
  BOTTOM w0.203: v5(104.75,37.92) 106.47,37.92 107.2,37.19 108.19,37.19 108.82,36.56 110.14,36.56 110.45,36.86 112.78,36.86 113.11,37.19 113.11,38.51 112.68,38.94 112.68,39.55 113.14,40.01 113.34,40.01 114.49,41.15 114.49,45.25 115.37,46.13 117.22,46.13 118.37,47.28 118.37,50.71 121.48,53.82 121.48,54.99 120.61,55.86 114.63,55.86 106.72,63.77 77.04,63.77 72.23,58.96 72.23,57.7 71.85,57.32 71.85,52.84 71.81,52.8 v5(71.81,52.2)
VCDT: length 8.7
  IN2 w0.058: v3(110.07,42.81) 110.07,42.56 109.82,42.32 109.41,42.32 109.12,42.02 108.73,42.02 107.37,40.67 107.37,40.37 107.62,40.12 v8(107.62,40.05)
  IN4 w0.058: v5(111.28,44.2) 111.28,43.81 110.27,42.81 v3(110.07,42.81)
  BOTTOM w0.089: R2303.1 111.73,44.56 112.52,44.56 R2302.2
VCN18_PMU: length 1.8
  IN2 w0.203: v8(106.02,37.65) 105.75,37.37 105.75,37.25 105.46,36.97 105.46,36.86 105.3,36.7 v3(105.29,36.7)
  IN4 w0.254: v3(105.29,36.7) 105.05,36.7 105.04,36.72 v5(104.73,36.72)
VDRAM1:
  vias: v1(107.02,45.39) v1(107.2,45.15) v1(107.37,45.4) v7(107.22,41.25)
VEFUSE_PMU: length 34.5
  TOP w0.254: C2135.1 95.41,44.61 v2(95.39,44.58) 95.66,44.3 95.66,43.8 96.05,43.42 v1(96.63,43.42)
  IN1 w0.203: v7(105.62,36.45) 105.57,36.4 105.57,35.8 105.67,35.7 105.67,35.6
  IN1 w0.254: 105.67,35.6 105.72,35.55 105.72,34.84 105.31,34.43 105.31,33.78 105.23,33.7 105.23,31.54 104.66,30.97 104.33,30.97 103.96,31.33 100.99,31.33 100.05,32.27 v1(100.05,33.11) 100.05,33.23 100.46,33.64 100.46,34.8 99.78,35.49 98.82,35.49 98.59,35.72 98.59,39.3 98.23,39.66 97.95,39.66 96.88,40.72 96.88,43.17 v1(96.63,43.42)
  IN2 w0.203: v2(95.39,44.58) 94.52,44.58 94.22,44.28 94.22,43.75 93.76,43.29 93.05,43.29 92.27,42.51 91.07,42.51 90.46,41.9 89.9,41.9 v8(89.83,41.96)
VFE28_PMU: length 6.3
  TOP w0.254: 111.06,37.42 110.32,37.42 109.69,38.05 U2001.R7
  TOP w0.381: 111.06,37.42 114.61,37.42 114.79,37.6 C2112.1
VIO18_MT6358: length 93.3
  TOP w0.203: v2(119.57,27.92) 119.57,26.78 120.28,26.07 121.23,26.07 121.46,25.83 124.24,25.83 124.63,25.44 124.63,23.49 125.2,22.92 125.2,17.53 126.32,16.41 126.32,13.85 v2(126.27,13.8)
  IN2 w0.203: v3(106.13,36.74) 106.02,36.64 v8(106.02,36.42) ; v2(119.57,27.92) 119.52,27.87 118.63,27.87 117.79,28.71 115.21,28.71 114.6,28.1 109.93,28.1 v3(109.68,27.85) ; v2(126.27,13.8) 127.9,15.42 129.37,15.42 v2(129.78,15.02) 130.21,15.45 133.92,15.45 136.15,17.68 136.81,17.68 137.69,16.81 137.69,15.72 138.16,15.25 142.65,15.25 143.11,15.7 143.11,16.39 143.77,17.05 143.77,19.59 144.45,20.26 144.45,21.13 144.71,21.39 144.71,24.82 146.67,26.78 146.67,27.92 146.97,28.23 146.97,29.72 144.56,32.14 144.56,33.13 144.69,33.25 144.69,33.66 144.36,33.99 144.36,34.8 144.92,35.36 144.92,36.2 v2(144.79,36.33)
  IN4 w0.203: v3(109.68,27.85) v5(109.68,27.24)
  BOTTOM w0.203: 104.3,29.73 104.31,29.72 106.53,29.72 106.73,29.93 108.57,29.93 109.68,28.82 v5(109.68,27.24) 110.2,27.24 113.65,30.69 113.65,35.41 113.34,35.72 R91299.1
  vias: v3(104.43,30.29) v4(103.89,30.21) v4(104.07,30.39) v4(104.15,30.09) v5(103.89,30.21) v5(104.07,30.39) v5(104.15,30.09)
VIO18_PMU_AP: length 36
  TOP w0.2: v2(92.06,36.11) 92.01,36.16 91.93,36.16 91.33,36.76 U1001.W27 ; 80.49,35.96 U1001.AA1
  TOP w0.203: 80.49,35.96 80.45,35.92 79.76,35.92 v2(79.56,35.72) 79.48,35.64 77.61,35.64
  TOP w0.254: U1001.E27 91.12,42.36 91.6,42.84 92.09,42.84 92.65,43.4 C4101.2 94.56,43.4 94.67,43.52 v2(94.67,44.08)
  TOP w0.305: v1(79.71,40.86) 79.89,41.03 79.89,42.66 79.41,43.14 77.83,43.14 77.75,43.06 76.82,43.06 76,42.24 76,36.74 76.87,35.87 77.38,35.87 77.61,35.64 ; v2(94.65,39.07) 93.73,39.07 93.43,39.38 91.4,39.38 91.21,39.56 91.04,39.56 U1001.M27
  IN1 w0.2: 80.52,40.48 80.9,40.09 80.9,40.09 v7(81.03,39.96)
  IN1 w0.203: v1(79.71,40.86) 80.09,40.48 80.52,40.48
  IN2 w0.203: v2(92.06,36.11) 92.01,36.11 91.93,36.03 91.44,36.03 v3(91.37,35.96) v8(91.01,35.96)
  IN2 w0.254: v2(94.67,44.08) 94.7,44.05 v3(94.7,43.67) ; v3(91.23,33.02) 91.23,33.36 v2(91.03,33.56) 90.95,33.64 90.95,34.35 v2(90.96,34.36) ; v3(80.04,35.3) 79.98,35.3 v2(79.56,35.72)
  IN2 w0.381: v2(94.65,39.07) 95,39.43 95.88,39.43 v3(96.69,40.24)
  IN4 w0.203: v5(92.59,36.23) 91.63,36.23 v3(91.37,35.96)
  vias: v1(84.72,29.2) v1(84.72,28.94) v1(84.72,28.69) v1(84.71,28.41) v1(84.79,29.66) v1(89.04,29.95) v1(89.04,29.7) v1(89.04,29.44) v2(84.72,29.2) v2(84.72,28.94) v2(84.72,28.69) v2(84.71,28.41) v2(84.79,29.66) v2(89.04,29.95) v2(89.04,29.7) v2(89.04,29.44) v3(84.64,30.37) v3(84.64,29.96) v3(88.73,29.57) v4(79.18,36.16) v4(79.26,35.9) v4(79.36,36.33) v4(79.51,36.06) v4(79.48,35.78) v4(79.61,36.31) v4(79.76,36.03) v4(79.76,35.78) v4(79.87,36.28) v4(80.02,35.78) v4(80.07,36.08) v4(80.25,35.88) v4(93.48,34.63) v4(98.18,46.95) v4(98.31,46.72) v4(98.43,46.95) v5(93.48,34.63)
VMC_PMU: length 3.4
  TOP w0.203: U2001.R9 110.09,38.85 110.1,38.87 110.86,38.87 111.32,39.33 112.1,39.33 112.43,39.66 C2124.1
VMCH_PMU: length 116.8
  TOP w0.089: R91261.1 47.67,45.13 47.86,45.32 v1(47.86,45.35) ; U2001.R10 109.71,39.17 110.74,39.17 111.2,39.63 111.98,39.63 112.13,39.78 112.13,40.4 112.28,40.54 113.06,40.54 113.37,40.86 113.71,40.86 114.09,41.24 C10552.1 114.46,44.03 114.77,44.33 v2(115.17,44.33)
  IN1 w0.076: v2(69.35,51.24) 68.49,51.24 66.19,48.94 65.22,48.94 62.82,46.54 59.38,46.54 58.84,46.01 57.44,46.01 56.8,45.37 47.89,45.37 v1(47.86,45.35)
  IN2 w0.058: v3(69.2,51.62) 69.2,51.39 v2(69.35,51.24) ; v2(115.17,44.33) v3(115.5,44.33)
  IN4 w0.058: v3(115.5,44.33) 115.53,44.35 115.53,44.66 v5(115.6,44.74) ; v3(69.2,51.62) v5(69.55,51.26)
  BOTTOM w0.089: v5(69.55,51.26) 69.55,51.47 71.2,53.11 71.2,57.86 71.93,58.6 71.93,60.04 76.62,64.73 107.11,64.73 115.02,56.82 121,56.82 122.44,55.39 122.44,53.42 119.41,50.4 119.41,46.68 117.9,45.17 116.04,45.17 v5(115.6,44.74)
VOLDN_BTN_ODL: length 152.9
  IN2 w0.058: v2(77.03,34.44) 77,34.44 76.94,34.5 v3(76.69,34.5) ; v3(77.28,58.71) 77.28,59.16 80.01,61.9 85.67,61.9 85.91,62.14 94.45,62.14 94.95,62.64 115.79,62.64 117.71,60.72 117.71,60.41 118.5,59.62 119.77,59.62 120.36,60.2 121.65,60.2 121.95,59.9 123.51,59.9 124.36,60.75 124.75,60.75 125.83,61.83 127.77,61.83 128.38,61.22 128.38,60.12 128.7,59.8 129.19,59.8 129.39,59.99 130.52,59.99 131.95,58.57 131.95,56.71 131.81,56.58 131.81,55.39 132.35,54.85 132.35,53.99 133.66,52.69 133.66,46.56 135.91,44.31 137.27,44.31 140.98,40.6 140.98,37.34 v3(141.08,37.24) ; v3(135.32,13.14) v2(135.01,12.83)
  IN3 w0.102: v3(135.32,13.14) 135.62,13.14 137.47,14.99 137.47,17.6 138.67,18.8 140.86,18.8 141.91,19.85 141.91,22.53 142.22,22.84 142.22,29.47 143.37,30.61 143.37,33.53 143.88,34.04 144.76,34.04 144.92,33.89 145.78,33.89 v3(146.31,34.42) 146.31,34.96 144.51,36.76 141.56,36.76 v3(141.08,37.24) ; v3(76.69,34.5) 76.67,34.5 76.52,34.64 76.52,42.79 75.32,44 75.32,46.17 74.61,46.88 74.61,55.85 77.28,58.52 v3(77.28,58.71)
  IN4 w0.058: v3(146.31,34.42) 146.29,34.45 v5(145.93,34.45)
  BOTTOM w0.089: J17.7 v5(145.93,34.45)
VOLUP_BTN_ODL: length 154.4
  IN2 w0.058: v3(135.32,13.9) v2(135.01,13.6) ; v2(77.02,33.79) 77,33.81 v3(76.69,33.81) ; v3(140.57,37.73) 140.57,40.68 137.16,44.1 135.83,44.1 133.43,46.49 133.43,52.62 132.14,53.91 132.14,54.77 131.6,55.31 131.6,56.66 131.74,56.8 131.74,57.59 131.1,58.22 128.08,58.22 127.57,58.73 127.57,59.05 128.15,59.63 128.15,61.14 127.68,61.62 125.93,61.62 124.85,60.53 124.44,60.53 123.6,59.69 121.87,59.69 121.56,59.99 120.45,59.99 119.86,59.41 118.42,59.41 117.5,60.32 117.5,60.63 115.71,62.43 95.12,62.43 94.62,61.92 86,61.92 85.76,61.68 80.36,61.68 v3(77.76,59.09)
  IN3 w0.102: v3(140.57,37.73) 140.57,37.09 141.21,36.46 144.38,36.46 145.68,35.16 145.68,34.63 145.4,34.35 v3(145.22,34.35) 143.67,34.35 142.98,33.66 142.98,30.79 141.92,29.72 141.92,22.97 140.78,21.83 140.78,20.5 141.03,20.25 141.03,19.51 140.7,19.18 138.51,19.18 137.09,17.76 137.09,15.07 135.92,13.9 v3(135.32,13.9) ; v3(76.69,33.81) 76.84,33.81 77.15,34.12 77.15,34.78 76.83,35.1 76.83,42.92 75.62,44.12 75.62,46.29 74.91,47 74.91,55.68 77.76,58.52 v3(77.76,59.09)
  IN4 w0.058: v5(144.84,33.89) 145.22,34.27 v3(145.22,34.35)
  BOTTOM w0.089: v5(144.84,33.89) 145.28,33.45 J17.9
VPROC11: length 3.3
  TOP w0.254: U2001.B7 U2001.A7 103.26,38.05 103.22,38.09
  TOP w0.508: 103.22,38.09 101.44,38.09 101.2,37.85
  vias: v1(100.49,36.46) v1(100.49,36.21) v1(100.49,35.95) v1(100.74,36.46) v1(100.74,36.21) v1(100.74,35.95)
VPROC12: length 4
  TOP w0.152: 103.5,38.71 103.64,38.85
  TOP w0.254: 103.64,38.85 U2001.A9 U2001.B9
  TOP w0.432: PL2002.1 101.25,38.71 103.5,38.71
VREF: length 3.8
  IN2 w0.203: 108.77,39.71 108.43,40.05 v8(108.42,40.05)
  IN2 w0.254: v3(110.18,39.6) 110.14,39.56 109.51,39.56 109.35,39.71 108.77,39.71
  IN4 w0.254: v5(110.6,39.64) 110.22,39.64 v3(110.18,39.6)
  BOTTOM w0.254: v5(110.6,39.64) 111.36,40.4 C2138.1
VRF12_PMU: length 2.1
  TOP w0.089: U2001.N15 U2001.P16
  IN1 w0.254: v1(109.25,41.65) 109.89,42.29 v1(109.89,42.88)
VRF18_PMU: length 8.6
  IN2 w0.203: v8(106.02,37.25) 106.02,37.16 105.72,36.86 105.72,35.34 105.8,35.26 105.8,33.88 106.13,33.54 106.13,32.54 105.47,31.88 105.47,29.88 v2(105.91,29.44)
VRTC28: length 7.2
  TOP w0.152: R8201.1 v2(113.83,40.2)
  IN2 w0.152: v2(113.83,40.2) 113.65,40.02 v3(113.39,40.02) ; v3(108.82,38.24) 108.63,38.24 v8(108.42,38.45)
  IN3 w0.152: v3(113.39,40.02) 112.86,40.55 111.82,40.55 110.38,39.11 110.16,39.11 109.29,38.24 v3(108.82,38.24)
  IN4 w0.152: v5(108.39,38.42) 108.64,38.42 v3(108.82,38.24)
VS1_LDO1: length 19.6
  TOP w0.089: v2(101.76,29.93) 101.35,30.33 C2113.1
  IN1 w0.2: 104.73,34.87 105.31,35.45 105.31,36.66 105.5,36.85 v7(105.62,36.85)
  IN1 w0.5: 104.73,34.87 104.73,34.02 104.68,33.97 104.68,32.23 104.5,32.05
  IN2 w0.152: v3(101.76,30.26) v2(101.76,29.93)
  IN3 w0.152: v3(105.29,38.23) 105.02,38.5 103.34,38.5 102.27,37.42 102.27,35.67 101.89,35.29 100.74,35.29 100.4,34.95 100.4,32.79 100.82,32.37 100.82,30.51 101.07,30.26 v3(101.76,30.26)
  vias: v1(103.87,31.94) v1(104.12,31.94) v1(104.55,32.05) v7(105.62,38.05) v8(105.62,38.05)
VS2: length 2.3
  TOP w0.254: U2001.L15 U2001.L16 108.02,41.76 108.85,42.58 108.85,43.22
VS2_PMU_R: length 13.9
  TOP w0.152: U2001.D16 105.13,41.75 105.13,41.82 v2(104.91,42.04)
  TOP w0.178: U2001.P13 v7(108.83,40.85)
  TOP w0.203: v7(108.83,40.85) U2001.N14 v7(108.42,40.85)
  IN2 w0.152: v3(103.77,43.29) 103.77,42.7 104.17,42.3 104.65,42.3 v2(104.91,42.04) ; v3(111.64,46.21) 111.64,46.31 111.72,46.39 111.72,46.41 v2(111.82,46.51)
  IN3 w0.152: v3(111.64,46.21) 111.41,45.98 111.41,45.39 110.73,44.71 109.08,44.71 108.42,44.05 107.52,44.05 107.09,43.62 106.71,43.62 106.21,44.13 104.28,44.13 103.77,43.62 v3(103.77,43.29)
  vias: v1(111.51,46.11) v1(111.51,45.83) v1(111.51,45.57) v7(109.2,40.45)
VSIM1_PMU: length 49
  TOP w0.152: v1(112.71,33.13) 112.61,33.23 112.61,33.41 112.34,33.67 112.34,33.98 111.87,34.46 C2121.1 112.63,34.61 v1(112.71,34.68) ; v1(93.94,24.75) 94.27,24.75 94.4,24.61 96.1,24.61 96.35,24.87 96.35,25.43 95.77,26.02 v1(95.77,26.83) C7406.2
  IN1 w0.06: 109.32,37.85 109,37.85 v7(108.82,38.02)
  IN1 w0.076: 109.32,37.85 109.35,37.82 109.66,37.82 110.63,36.84 110.82,36.84
  IN1 w0.152: v1(112.71,34.68) 112.71,34.72 112.66,34.77 112.66,36.01 111.82,36.84 110.82,36.84 ; v7(90.24,33.96) 90.48,33.71 90.48,33.54 90.85,33.17 90.85,32.96 90.58,32.7 90.58,31.12 91.11,30.6 91.11,29.41 91.99,28.52 91.99,27.63 92.35,27.27 92.35,26.02 93.16,25.22 93.42,25.22 93.89,24.75 v1(93.94,24.75) ; v1(112.71,33.13) 112.73,33.1 113.01,33.1 113.6,32.52 113.6,29.98 112.3,28.68 110.38,28.68 107.65,25.95 106.22,25.95 105.72,25.46 103.56,25.46 103.18,25.84 101,25.84 100.57,25.41 97.85,25.41 96.83,26.42 96.18,26.42 v1(95.77,26.83)
VSIM2_PMU: length 153.3
  TOP w0.508: v6(63.38,51.47) 63.64,51.21 65.77,51.21 67.01,52.46 67.01,53.73 67.75,54.46 71.17,54.46 v6(73.21,56.5) ; v6(36.94,24.01) 35.92,22.99 35.92,16.84 34.59,15.51 34.57,15.51 33.05,13.99 23.55,13.99 21.08,11.53 R91207.1 20.07,11.53 19.57,11.03
  IN1 w0.508: 40.62,36.23 40.62,34.75 39.1,33.23 39.1,32.52 36.94,30.36 v6(36.94,24.01)
  IN2 w0.508: v2(40.62,36.46) 40.83,36.66 42.6,36.66 42.99,37.05 51.78,37.05 54.46,39.73 v3(54.95,39.73)
  IN3 w0.508: v3(113.09,37.73) 113.22,37.73 117.15,41.66 117.15,43.87 117.1,43.92 117.1,44.76 116.43,45.43 116.43,47.49 116.04,47.88 116.04,48.39 114.99,49.43 114.99,51.09 115.76,51.85 115.76,54.03 113.52,56.27 113.52,58.07 110.42,61.17 96.25,61.17 95.45,60.37 79.39,60.37 78.82,59.8 77.26,59.8 76.59,59.12 76.59,58.58 74.51,56.5 v6(73.21,56.5) ; v6(63.38,51.47) 63.38,49.67 63.15,49.45 63.15,48.62 62.49,47.96 62.49,47.25 58.68,43.44 56.4,43.44 54.95,41.99 v3(54.95,39.73)
  vias: v1(113.34,37.96) v1(113.6,37.96) v2(40.11,36.46) v2(113.34,37.96) v2(113.6,37.96) v7(109.28,39.25)
VSYSSNS: length 1.1
  IN2 w0.058: v3(108.08,39.68) 108.11,39.65 v8(108.42,39.65)
  IN4 w0.058: v5(107.73,39.76) 108,39.76 v3(108.08,39.68) 108.12,39.64 v5(108.41,39.64)
VUSB_PMU: length 41.5
  IN1 w0.203: v2(93.79,43.87) 93.58,43.67 93.58,43.62 92.7,42.74 92.59,42.74 92.46,42.6 91.8,42.6 91.48,42.29 91.48,41.94 91.21,41.67 90.77,41.67 90.49,41.96 v7(90.24,41.96) ; v7(108.82,38.45) 108.95,38.57 109.49,38.57 109.65,38.41 110,38.41 110.68,37.73 112.88,37.73 113.17,37.45 113.64,37.45 114.05,37.86 v1(114.05,37.96) 114.21,38.12 114.21,40.37 113.87,40.7 113.87,42.33 113.65,42.55 113.65,43.95 v2(113.69,43.99)
  IN2 w0.203: v2(93.79,43.87) 93.79,44.35 94.39,44.96 96.02,44.96 96.6,45.55 v3(96.73,45.55) ; v2(113.69,43.99) 113.64,43.99 112.96,44.67 v3(112.91,44.67)
  IN3 w0.203: v3(96.73,45.55) 96.8,45.55 96.95,45.7 99.7,45.7 100.49,44.91 101.86,44.91 102.24,44.53 102.24,43.14 102.93,42.45 105.01,42.45 105.11,42.55 107.89,42.55 109.36,44.02 111.46,44.02 111.78,44.34 112.53,44.34 112.86,44.67 v3(112.91,44.67)
VXO22_PMU: length 4.1
  TOP w0.203: v1(111.49,36.48) 111.51,36.46 111.84,36.46 112.42,35.88 C2111.1
  IN1 w0.203: v1(111.49,36.48) 111.46,36.51 110.69,36.51 109.58,37.62 109.26,37.62 v7(109.22,37.65)
WIFI_EN_1V8: length 93.2
  TOP w0.089: v2(133.26,64.27) 132.77,63.79 131.92,63.79 Q723.1
  IN1 w0.06: v7(82.64,41.16) 82.44,41.36 82.44,41.69 82.37,41.76 81.32,41.76 80.53,42.55 80.53,42.71
  IN1 w0.076: 80.53,42.71 79.26,43.97 77.48,43.97 77.28,43.77 75.73,43.77 73.69,45.8 73.69,51.31 v2(72.6,52.41)
  IN2 w0.058: v2(72.6,52.41) 72.19,52.82 72.19,57.42 72.37,57.61 72.37,59.2 75.5,62.32 75.5,63.37 77.38,65.25 117.19,65.25 118.35,64.1 122.33,64.1 122.64,63.79 125.64,63.79 126.27,64.42 127.69,64.42 128.06,64.05 129.96,64.05 130.36,63.66 132.64,63.66 v2(133.26,64.27)
WIFI_EN_3V3: length 15.4
  TOP w0.508: 133.08,60.73 133.05,60.75 132.54,60.75 131.86,61.44 Q723.3 132.42,62.97 132.75,62.64 R90898.2 138.22,62.64 138.76,63.18 R90624.2
  IN2 w0.254: v2(133.23,61.05) 133.35,61.05 v3(133.59,60.81) 133.38,60.61 v2(133.21,60.61)
  IN4 w0.508: 134.55,57.46 134.25,57.77 134.25,58.05 133.54,58.76 133.54,60.76 v3(133.59,60.81)
  vias: v4(134.63,57.26) v4(134.89,57.26) v5(134.63,57.26) v5(134.89,57.26)
WLAN_RF_KILL_L: length 135.7
  IN1 w0.06: 81.35,32.39 81.83,32.87 81.83,33.72 81.97,33.86 81.97,34.13 82.12,34.28 82.12,34.66 82.02,34.76 v7(81.83,34.76)
  IN1 w0.076: v2(67.19,36.79) 67.29,36.89 67.29,37.65 67.37,37.73 71.48,37.73 71.99,38.24 72.67,38.24 73.08,37.83 73.08,35.33 74.46,33.95 75.16,33.95 75.57,33.53 75.57,31.22 76.03,30.77 76.03,29.34 77.22,28.15 78.3,28.15 80.04,29.9 80.04,31.08 81.35,32.39
  IN2 w0.058: v2(67.19,36.79) 67.19,36.84 67.14,36.89 v3(66.58,36.89)
  IN3 w0.102: v3(131.43,48.39) 131.05,48.77 131.05,50.17 130.17,51.05 130.17,54.64 127.65,57.16 126.71,57.16 124.49,59.38 124.49,62.01 121.65,64.85 121.65,66.03 120.75,66.94 76.09,66.94 71.83,62.67 71.44,62.67 67.47,58.71 67.47,54.3 64.7,51.53 64.7,48.98 64.83,48.85 64.83,46.56 64.3,46.03 64.3,45.45 66.63,43.11 66.63,42.35 66.48,42.2 66.48,40.9 66.35,40.77 66.35,37.14 66.58,36.91 66.58,36.89 v3(66.58,36.89)
  IN4 w0.058: v5(131.81,48.57) 131.61,48.57 v3(131.43,48.39)
  BOTTOM w0.089: v5(131.81,48.57) R91141.2
XO_CEL: length 100.4
  TOP w0.089: R91257.1 63.33,34.96 63.48,34.8 63.48,34.17 64.14,33.51 67.19,33.51 67.24,33.56 70.47,33.56 70.68,33.34 73.33,33.34 73.82,32.85 73.82,21.6 75.98,19.44 75.98,15.73 76.06,15.65 77.75,15.65 v2(77.88,15.78) ; U2001.R3 110.18,35.89 110.18,34.68 110.28,34.58 C10689.1
  IN2 w0.058: v2(110.43,34.55) 110.45,34.55 110.62,34.38 110.62,33.92 111.07,33.48 111.36,33.48 111.6,33.23 112.58,33.23 113.19,32.62 114.21,32.62 114.75,33.17 115.79,33.17 116.82,34.19 116.82,34.3 v3(117.13,34.6) ; v3(78.29,15.78) v2(77.88,15.78)
  IN3 w0.102: v3(117.13,34.6) 116.98,34.45 116.98,33.1 116.49,32.62 116.49,30.33 116.85,29.98 116.85,28.92 115.95,28.02 115.95,23.4 114.36,21.81 114.36,18.5 112.84,16.97 112.71,16.97 111.31,15.58 110.47,15.58 109.51,14.61 101.84,14.61 101.33,14.1 96.31,14.1 96.1,14.31 91.47,14.31 89.9,15.88 89.11,15.88 88.6,16.39 84.79,16.39 84.36,15.96 82.48,15.96 81.82,15.3 79.31,15.3 78.85,15.75 78.32,15.75 v3(78.29,15.78)
XO_SOC: length 5.5
  TOP w0.089: R8001.1 113.69,35.25 111.35,35.25 110.91,35.69 110.76,35.69 109.71,36.74 109.33,36.74 U2001.P4
XO_WCN: length 9.2
  TOP w0.089: v1(111.08,35.06) 111.11,35.06 111.15,35.01 113.65,35.01 R90435.1
  IN1 w0.06: 109.41,35.74 109.33,35.82 109.19,35.82 109.06,35.95 109.06,36.34 v1(109.17,36.45)
  IN1 w0.076: 109.41,35.74 109.41,35.64 109.75,35.3 109.75,34.88 110.03,34.6 110.03,33.92 110.22,33.72 110.71,33.72 111.03,34.04 111.44,34.04 111.68,34.28 111.68,34.72 111.34,35.06 v1(111.08,35.06)
XTAL1: length 7
  TOP w0.089: U2001.N1 109.12,35.35 109.19,35.35 109.68,34.86 109.68,34.26 109.94,34.01 C10605.1 109.94,32.52 110.14,32.31 110.42,32.31 110.57,32.16 110.57,30.51 110.36,30.3 X8101.1
XTAL2: length 5
  TOP w0.089: X8101.3 111.42,31.67 110.5,32.59 C10606.1 110.5,32.82 110.19,33.13 110.19,34.09 109.94,34.35 109.94,34.95 109.24,35.65 U2001.P1
ZQ0_A: length 8.9
  IN2 w0.075: v3(79.56,55.86) 79.56,57.92 v2(80.37,58.74)
  IN2 w0.2: v8(78.7,50.7) 78.7,51.05 v3(78.75,51.09)
  IN3 w0.075: v3(78.75,51.09) 78.75,52.43 78.59,52.6 78.59,52.89 78.79,53.09 78.82,53.09 79.08,53.36 79.08,55.09 79.56,55.57 v3(79.56,55.86)
ZQ1_A: length 7.8
  TOP w0.089: v2(81.31,58.75) R4405.1
  IN2 w0.075: v3(79.99,56.16) 79.99,57.54 81.04,58.59 81.04,58.68 81.12,58.75 v2(81.31,58.75)
  IN2 w0.2: v8(78.7,53.1) 78.7,52.97 v3(78.93,52.75)
  IN3 w0.075: v3(78.93,52.75) 78.95,52.75 78.95,53.02 79.23,53.29 79.23,55.03 79.89,55.69 79.89,56.07 v3(79.99,56.16)
ZQ2_A: length 4.9
  IN2 w0.075: v8(82.61,55.5) 81.85,55.5 81.17,56.17 81.17,57.22 82.56,58.6 v2(82.56,58.75)
N39948619: length 12.5
  TOP w0.178: U6.5 124.9,29.9 124.85,29.85 124.85,29.24 v6(124.32,28.71)
  IN3 w0.762: v6(124.32,28.71) 124.52,28.5 124.52,26.73 125.89,25.36 130.51,25.36 131.53,24.34 v6(131.53,23.83)
N39949141: length 2.3
  TOP w0.089: U6.24 123.3,34.82 123.12,35 122.55,35 121.99,35.57 R709.2
N39970803: length 3.6
  TOP w0.508: R720.1 131.3,32.84 131.3,31.88 130.79,31.38 C488.2
N39984767: length 1.4
  TOP w0.508: C440.1 R721.1
N45881871: length 1.7
  IN2 w0.076: v3(105.39,42.03) 105.21,41.84 105.21,41.27 v8(105.22,41.25)
  IN4 w0.076: v5(104.91,41.36) 104.91,41.54 v3(105.39,42.03)
N45901165: length 4.4
  IN2 w0.058: v3(109.15,38.8) 109.1,38.85 v8(108.82,38.85)
  IN4 w0.058: v5(110.02,38.54) 109.41,38.54 v3(109.15,38.8)
  BOTTOM w0.089: C2125.1 112.18,38.19 VIO28_PMU.1 111.62,38.75 110.22,38.75 v5(110.02,38.54)
N46231484: length 7.1
  TOP w0.178: R90650.2 114.95,36.24 114.69,35.98 113.73,35.98 v1(113.05,36.67)
  IN1 w0.178: v7(109.22,38.05) 109.38,38.05 109.43,38 109.86,38 110.7,37.16 112.64,37.16 113.05,36.76 v1(113.05,36.67)
N46231535: length 16.5
  TOP w0.203: R90652.2 C2103.1 114.31,47.02 114.77,46.56 114.77,46.36 115.12,46.01 115.12,45.45 113.88,44.2 113.88,41.45 113.6,41.17 113.28,41.17 v1(113.25,41.19)
  IN1 w0.178: v7(108.82,39.65) 109.06,39.65 109.16,39.55 109.96,39.55 110.54,38.97 111.02,38.97 111.41,38.58 113.56,38.58 113.73,38.76 113.73,39.21 113.7,39.25 113.7,39.68 113.06,40.32 113.06,40.95 113.25,41.14 v1(113.25,41.19)
N46231597: length 3.7
  TOP w0.178: U2001.P9 109.5,38.57 109.94,38.57 110,38.51 110.96,38.51 111.44,38.03 C2102.1
  TOP w0.254: C2102.1 111.74,38.18 R90651.2
