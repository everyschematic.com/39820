# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N46233111: length 2.5
  TOP w0.254: U2001.R15 109.83,41.25 110.67,42.08 C2117.1
  TOP w0.406: C2117.1 110.9,42.13 R90654.2
N46264414: length 8.5
  TOP w0.102: v8(107.6,38.87) 107.63,38.85 U2001.L9
  IN2 w0.102: v3(110.65,36.44) 110.65,36.47 110.46,36.66 110.46,37.86 110.01,38.31 109.66,38.31 109.51,38.47 109.51,39.02 109.34,39.19 107.92,39.19 v8(107.6,38.87)
  IN4 w0.102: v3(110.65,36.44) 110.7,36.38 v5(111.08,36.38)
  BOTTOM w0.102: R91299.2 R90656.2 C2139.1 v5(111.08,36.38)
N46324535: length 2.4
  TOP w0.6: VMODEM.1 104.61,44.08 105.11,43.57 105.11,42.65 105.57,42.19
N46439912: length 1.6
  TOP w0.089: U2001.P8 109.34,38.34 109.79,38.34 110.12,38 VLDO28_PMU.1
N51761964: length 4.2
  TOP w0.2: v8(87.83,35.96) v8(88.24,35.56) v8(87.83,35.16) 87.64,35.16 87.24,34.76 U1001.AD16 v8(86.24,35.16) v8(86.64,35.56) v8(86.24,35.96)
  vias: v1(94.34,30.2) v1(94.34,29.93) v1(94.34,29.68) v1(94.34,29.42) v1(94.6,30.23) v1(94.6,29.96) v1(101.49,45.48) v1(101.61,46.7) v1(101.61,46.42) v1(101.63,46.16) v1(101.56,45.76) v1(101.79,46.93) v1(101.76,45.93) v1(101.84,45.68) v1(101.79,45.43) v1(101.86,46.67) v1(101.86,46.42) v1(101.89,46.16) v2(94.34,30.2) v2(94.34,29.93) v2(94.34,29.68) v2(94.34,29.42) v2(94.6,30.23) v2(94.6,29.96) v2(101.49,45.48) v2(101.61,46.7) v2(101.61,46.42) v2(101.63,46.16) v2(101.56,45.76) v2(101.79,46.93) v2(101.76,45.93) v2(101.84,45.68) v2(101.79,45.43) v2(101.86,46.67) v2(101.86,46.42) v2(101.89,46.16) v3(86.31,35.55) v3(86.59,35.92) v3(86.59,35.21) v3(87.9,35.51) v3(88.2,35.21) v3(94.34,28.96) v3(94.67,29.62) v3(100.41,45.73) v3(100.54,46.13) v3(100.82,45.68) v3(100.9,46.59) v3(100.95,46.18) v3(101.23,45.86) v3(101.16,45.43) v3(101.3,46.84) v3(101.28,46.44) v4(93.42,30.39) v4(93.58,30.61) v4(93.71,30.39) v4(93.87,30.58) v4(94.06,30.38) v4(94.25,30.56) v4(94.52,30.56) v4(94.7,30.38) v4(99.98,46.39) v4(100.08,46.16) v4(100.06,45.9) v4(100.21,46.64) v4(100.26,46.36) v4(100.34,45.12) v4(100.49,46.77) v4(100.49,46.49) v4(100.54,44.97) v4(100.69,46.95) v4(100.74,44.82) v4(100.77,45.1) v4(100.97,46.95) v4(100.97,44.95) v4(100.97,44.69) v4(101.24,44.97) v4(101.23,44.7) v4(101.52,45.55) v4(101.49,45.21) v4(101.5,44.88) v4(101.58,46.64) v4(101.58,46.01) v5(91.17,32.46) v5(91.17,32.2) v5(91.42,32.46) v5(91.42,32.2) v5(92.36,32.46) v5(92.36,32.2) v5(92.62,32.46) v5(92.62,32.2) v5(93.56,32.35) v5(93.56,32.09) v5(93.81,32.35) v5(93.81,32.09) v5(94.75,32.4) v5(94.75,32.14) v5(95,32.4) v5(95,32.14) v9(86.64,35.57) v9(86.92,36) v9(86.92,35.17) v9(86.98,35.57) v9(87.31,35.57) v9(87.49,35.85) v9(87.54,35.19) v10(86.64,35.57) v10(86.92,36) v10(86.92,35.17) v10(86.98,35.57) v10(87.31,35.57) v10(87.49,35.85) v10(87.54,35.19)
N51955732: length 3.1
  TOP w0.254: v8(91.37,35.55) 91.35,35.55 91.33,35.56 U1001.AB27
  IN2 w0.254: v3(91.78,35.57) 91.75,35.55 v8(91.37,35.55)
  IN4 w0.254: v3(91.78,35.57) 91.88,35.57 92.11,35.8 92.59,35.8 v5(93.04,35.35)
  BOTTOM w0.254: v5(93.04,35.35) 93,35.31 93,34.8 93.03,34.78 R90622.1
N52164405: length 1.6
  TOP w0.203: C6106.1 106.42,34.53 U2001.G2
N52164407: length 2.8
  TOP w0.203: v1(105.9,34.05) 106.29,33.66 C6106.2
  IN1 w0.203: v1(105.98,36.04) 106.13,35.89 106.13,34.66 105.95,34.47 105.95,34.1 v1(105.9,34.05)
N52164418: length 3.1
  TOP w0.152: C6104.2 106.82,33.52 106.82,34.62 106.74,34.7 106.74,35.56 U2001.H1
N52164422: length 6.2
  TOP w0.152: C6105.2 107.48,31.14 106.92,31.71 106.92,32.98 106.7,33.19 106.04,33.19 105.52,33.71 105.52,34.18 105.85,34.51 105.85,35.26 105.97,35.38 105.97,35.6 U2001.F1
N52164426: length 2.7
  TOP w0.203: R90659.1 107.25,35.31 107.15,35.41 107.15,35.8 106.9,36.05 U2001.H2
  TOP w0.381: R90659.1 107.25,34.12 107.48,33.89 C6104.1
N52164464: length 5.9
  IN2 w0.508: v2(107.22,36.35) 107.22,35.84 107.04,35.65 107.04,34.8 107.15,34.7 107.15,34.14 107.27,34.01 107.27,32.07 107.17,31.96 107.17,31.02 107.45,30.74
  vias: v1(107.63,30.39) v1(107.58,30.13) v2(107.63,30.39) v2(107.58,30.13)
N52167840: length 1.7
  TOP w0.089: R8201.2 114.46,40.2 114.47,40.19 C8202.1
N52329114: length 3.7
  TOP w0.06: v1(80.3,34.05) 79.82,33.56
  TOP w0.089: 79.82,33.56 79.74,33.49 79.74,33.41 I2C1_SCL_MTK.1 79.36,33.28 79.13,33.51 R1104.1
  IN1 w0.06: v7(81.83,34.36) 81.75,34.36 81.6,34.5 81.37,34.5 80.99,34.13 80.38,34.13 v1(80.3,34.05)
N52329116: length 6.5
  TOP w0.089: v1(80.04,32.52) 79.84,32.31 78.88,32.31 78.7,32.14 I2C1_SDA_MTK.1 78.19,32.14 77.74,31.68 76.89,31.68 76.76,31.82 R1103.1
  IN1 w0.06: v7(81.77,34.02) 81.77,34.03 81.69,34.1 81.34,34.1 81.18,33.94 81.18,33.79 81.09,33.7
  IN1 w0.076: v1(80.04,32.52) 80.09,32.57 80.09,32.7 81.09,33.7
N53426645: length 1.7
  TOP w0.089: U2001.R6 110.31,36.96 110.65,36.96 VCN28_PMU.1
N53427825: length 10.5
  TOP w0.089: v1(110.6,40.13) 110.09,40.13 109.96,40.01 109.57,40.01 109.22,39.66 U2001.P11
  IN1 w0.076: v1(110.6,40.13) 110.68,40.13 111,39.82 111.93,39.82 112.3,40.19 112.3,41.36 113.35,42.41 113.35,44.14 113.75,44.53 113.75,45.71 113.83,45.78 v1(114.51,45.78)
N53513826: length 8.3
  TOP w0.089: VCN33_PMU.1 116.11,40.95 115.98,40.82 115.43,40.82 115.2,40.6 113.57,40.6 v2(113.47,40.49)
  IN2 w0.058: v2(113.47,40.49) 112.12,40.49 112.1,40.52 111.56,40.52 111.1,40.06 110.07,40.06 109.79,40.35 109.56,40.35 109.26,40.05 v8(108.82,40.05)
N54695190: length 3.4
  TOP w0.089: v2(104.81,36.36) 104.9,36.45 U2001.D3
  IN2 w0.058: v2(102.62,35.01) 102.62,35.16 102.75,35.29 103.84,35.29 104.17,35.61 104.17,35.85 104.68,36.36 104.8,36.36 v2(104.81,36.36)
N54973657: length 4.2
  TOP w0.089: R90373.2 129.85,47.07 129.8,47.12 128.89,47.12 128.26,47.76 127.62,47.76 127.08,48.29 127.08,48.67 U6517.B2
N54973804: length 2.8
  TOP w0.089: R90554.1 128.63,49.28 127.74,50.17 127.09,50.17 U6517.E2
N54973834: length 5.2
  TOP w0.089: R90368.2 122.26,46.84 123.17,47.76 v2(123.45,47.76)
  IN2 w0.058: v2(123.45,47.76) 123.45,47.91 123.81,48.27 123.81,49.24 124.24,49.67 124.5,49.67 124.6,49.77 124.6,50.19 v2(124.84,50.42)
N54973848: length 3.2
  TOP w0.089: U6517.H1 128.24,51.92 128.43,52.11 R90371.1
N54975848: length 1.1
  IN2 w0.058: v2(137.57,59.39) 137.39,59.58 v3(137.39,60.1)
  IN4 w0.058: v3(137.39,60.1) v5(137.39,59.76)
N54975861: length 1.1
  IN2 w0.058: v3(137.09,59.09) v2(136.97,59.39)
  IN4 w0.058: v5(136.89,59.76) 136.89,59.29 v3(137.09,59.09)
N54975866: length 0.8
  IN2 w0.058: v2(136.2,59.84) 136.2,60.03 v3(136.33,60.15)
  IN4 w0.058: v3(136.33,60.15) 136.39,60.09 v5(136.39,59.76)
N54975879: length 0.8
  IN2 w0.058: v2(135.44,59.84) 135.7,60.1 v3(135.7,60.1)
  IN4 w0.058: v5(135.89,59.73) 135.89,59.9 v3(135.7,60.1)
N54975900: length 1.5
  IN2 w0.058: v3(134.15,59.21) 134.33,59.39 v2(134.33,59.49)
  IN4 w0.058: v5(134.2,58.86) 134.2,59.16 v3(134.15,59.21)
  BOTTOM w0.089: U1007.48 134.33,58.72 v5(134.2,58.86)
N54975905: length 0.7
  IN2 w0.058: v3(134.86,58.03) 134.8,58.09 v2(134.48,58.09)
  IN4 w0.058: v3(134.86,58.03) v5(135.1,58.26)
N54976308: length 7
  BOTTOM w0.089: TP9060.1 138.65,62.39 140.12,62.39 142.14,60.37 143.15,60.37 143.39,60.13 U1007.64
N54976310: length 6
  BOTTOM w0.089: U1007.65 143.89,60.15 143.37,60.66 142.19,60.66 139.77,63.09 TP9061.1
N54990858: length 6
  TOP w0.089: v2(43.26,5.31) 43.34,5.24 43.34,4.49 R90438.2
  IN2 w0.058: v2(43.26,5.31) 43.26,5.52 42.93,5.85 42.32,5.85 v3(42.22,5.95)
  IN4 w0.058: v3(42.22,5.95) 42.12,5.85 v5(41.77,5.85)
  BOTTOM w0.089: CON16.33 41.3,5.38 v5(41.77,5.85)
N54990873: length 3.6
  BOTTOM w0.089: R90439.1 42.53,11.06 41.7,10.23 CON16.32
N54990958: length 3.2
  TOP w0.089: R476.2 40.48,4.12 40.48,4.28 40.26,4.5 v2(40.19,4.5)
  IN2 w0.058: v2(40.19,4.5) 39.99,4.71 39.99,4.81 v3(39.96,4.83)
  IN4 w0.058: v5(40.9,4.45) 40.37,4.45 39.99,4.83 v3(39.96,4.83)
  BOTTOM w0.089: CON16.35 v5(40.9,4.45)
N54990985: length 3.6
  BOTTOM w0.089: CON16.16 44.9,10.5 R331.1
N54991151: length 3.9
  BOTTOM w0.089: CON16.40 40.1,9.79 R512.1
N54991199: length 5.7
  BOTTOM w0.089: R90682.1 46.02,13.09 46.02,12.93 46.31,12.64 46.31,10.89 45.3,9.88 CON16.14
N55124912: length 2.9
  TOP w0.089: U6517.G6 124.57,51.69 124.2,51.69 124.09,51.8 124.09,52.13 124.35,52.39 124.35,53.05 123.99,53.42 R90628.1
N55125049: length 2.8
  TOP w0.089: U6517.C3 126.09,49.18 126.09,47.09 R90892.2
N55392694: length 4.7
  TOP w0.089: v1(53.81,20.02) 53.7,20.02 53.65,20.07 52.85,20.07 52.68,20.24 52.68,20.72 52.33,21.08 R90389.2
  IN1 w0.076: v1(55.48,18.91) 55.43,18.91 55.18,19.16 54.44,19.16 53.81,19.79 v1(53.81,20.02)
N55392696: length 5.2
  TOP w0.089: v1(54.19,19.87) 54.19,20.16 53.99,20.35 53.3,20.35 52.97,20.68 R90388.2
  IN1 w0.076: v1(54.19,19.87) 54.39,19.67 54.77,19.67 54.85,19.74 55.74,19.74 55.96,19.51 55.96,19.18 56.24,18.91 v1(56.48,18.91)
N55392702: length 6.2
  TOP w0.089: D2736.1 56.54,23.7 55.58,22.75 55.58,20.99 55.74,20.83 55.74,19.15 U124.F8
N55392761: length 3.3
  TOP w0.089: U124.H4 57.23,16.65 57.23,16.25 57.32,16.16 58.4,16.16 59.27,15.29 R90441.1
N55392763: length 2.4
  TOP w0.089: U124.J2 57.54,15.9 59.11,14.33 R90442.2
N55392804: length 2.1
  TOP w0.071: U124.E1 55.59,15.3 55.59,14.47 55.88,14.18 55.88,13.84 R90385.2
N55392806: length 2.1
  TOP w0.071: U124.F1 55.81,15.24 55.81,14.56 56.1,14.27 56.1,13.84 R90384.2
N55392842: length 5.6
  IN2 w0.056: v3(55.3,15.14) 55.3,15.17 55.63,15.5 55.63,15.71 v2(55.48,15.85)
  IN4 w0.056: v3(55.3,15.14) 55.3,15.17 55.53,15.4 55.53,15.58 55.71,15.75 56.15,15.75 56.52,15.38 56.52,14.51 56.24,14.23 v5(56.24,13.21)
  BOTTOM w0.071: R90383.2 55.83,12.8 v5(56.24,13.21)
N55392848: length 4.1
  IN2 w0.056: v2(55.98,15.85) 55.96,15.85 55.83,15.73 55.83,15.3 55.91,15.22 v3(55.91,15.14)
  IN4 w0.056: v3(55.91,15.14) 55.74,15.32 55.74,15.5 55.79,15.55 56.07,15.55 56.32,15.3 56.32,14.59 56.04,14.31 56.04,13.52 55.99,13.47 v5(55.83,13.47)
N55392869: length 4.9
  TOP w0.089: U124.C1 54.31,15.24 54.31,14.81 54.08,14.59 v2(53.88,14.59)
  IN2 w0.058: v3(54.08,14.87) 54.08,14.79 v2(53.88,14.59)
  IN4 w0.058: v3(54.08,14.87) 54.08,15.37 53.83,15.63 v5(53.07,15.63)
  BOTTOM w0.089: R90680.1 R90937.1 53.35,16.29 53.07,16.01 v5(53.07,15.63)
N55392976: length 2.5
  TOP w0.089: R90681.1 51.94,16.39 52.2,16.64 53.74,16.64 U124.B3
N55392985: length 0.7
  IN2 w0.058: v2(53.98,17.91) 53.66,17.91 v3(53.65,17.91)
  IN4 w0.058: v5(53.42,17.66) 53.63,17.87 53.63,17.89 v3(53.65,17.91)
N55392987: length 4.8
  TOP w0.203: R91188.1 R90386.2
  IN2 w0.203: v2(59.78,8.18) 59.78,7.36 v2(61.74,5.4) v2(61.74,4.75)
N55392989: length 4
  TOP w0.203: R91189.1 R90387.2
  IN2 w0.203: v2(57.09,5.4) v2(57.09,6.05) 58.75,7.7 v2(58.75,8.2)
N55504545: length 2.2
  TOP w0.508: R90835.1 131.53,37.52 D761.3
N55506209: length 1.7
  BOTTOM w0.508: C10494.1 142.19,22.9 142.1,22.99 R90839.2
N55549814: length 2
  TOP w0.089: C10505.1 145.43,16.56 144.98,17 144.42,17 144.3,16.88 U6559.21
N55550359: length 2
  TOP w0.089: U6559.29 141.3,19.78 141.59,20.07 R90853.1
N55550482: length 3.2
  TOP w0.203: R90855.1 143.53,20.83 R90854.1 142.58,20.55 141.7,19.68 U6559.28
N55694571: length 3.9
  BOTTOM w0.089: R90845.1 R90899.2 134.65,47.46 134.73,47.38 136,47.38 136.39,47.77 U1007.27
N55757845: length 2.6
  TOP w0.089: R90688.1 127.69,53.46 126.58,52.34 126.58,51.66 U6517.G3
N56177052: length 5.3
  TOP w0.089: R90611.1 45.55,24.06 45.47,23.98 v2(45.47,22.99) 45.47,22.56 45.83,22.21 U49.3
  IN2 w0.058: v3(45.96,22.87) 45.83,22.99 v2(45.47,22.99)
  IN4 w0.058: v4(45.98,22.38) 45.96,22.41 v3(45.96,22.87)
  IN5 w0.076: v4(45.98,22.38) 46.07,22.3 v5(46.07,21.22)
N56177260: length 3.1
  TOP w0.089: U49.1 48.37,22.41 48.14,22.64 R90425.2 R90428.2 49.15,22.9 49.34,23.09 R90640.1
N56177291: length 2.2
  TOP w0.089: U49.2 47.1,22.51 R90424.2 R90429.2
N56177312: length 2.2
  TOP w0.089: U49.6 45.83,14.87 45.86,14.84 R90431.1 R90426.1
N56177318: length 2.2
  TOP w0.089: U49.5 44.56,14.99 44.59,14.96 R90430.1 R90427.1
N56253380: length 2.2
  TOP w0.203: C9047.1 12.44,28.57 12.3,28.71 12.3,29.12 U6504.D2
N56253382: length 2.5
  TOP w0.203: C9047.2 v1(11.66,28.07)
  IN1 w0.203: v1(11.66,28.07) 11.66,28.62 11.95,28.91 11.95,29.4 v1(11.84,29.51)
N56253413: length 2.4
  IN1 w0.076: v1(9.26,31.38) 10.02,31.38 10.53,30.86 v1(11.5,30.86)
N56318932: length 3.4
  IN2 w0.058: v2(55.53,13.12) 55.48,13.12 55.48,13.11 55.13,13.11 v3(55.1,13.09)
  IN4 w0.058: v5(55.35,13.47) 55.35,13.34 v3(55.1,13.09)
  BOTTOM w0.089: Q807.2 54.56,14.96 54.44,14.84 R91311.2 54.75,14.59 54.85,14.48 54.85,14.23 55.35,13.72 v5(55.35,13.47)
N56318941: length 3.8
  IN2 w0.058: v2(56.37,13.12) 56.09,12.83 v3(55.94,12.83)
  IN4 w0.058: v3(55.94,12.83) 55.79,12.68 v5(55.35,12.68)
  BOTTOM w0.089: R91313.2 54.44,13.87 54.97,13.34 54.97,12.91 54.7,12.63 Q808.2 54.62,12.58 55.25,12.58 v5(55.35,12.68)
N56324356: length 11.1
  IN2 w0.058: v2(107.2,36.8) 107.22,36.82 107.34,36.82 107.57,36.6 107.57,35.33 107.63,35.27 v3(107.65,35.27) ; v3(99.6,34.68) 99.6,34.66 v2(100.03,34.23)
  IN4 w0.058: v3(107.65,35.27) 107.48,35.27 v5(107.23,35.02) ; v5(100.29,34.55) 99.91,34.55 99.78,34.68 v3(99.6,34.68)
  BOTTOM w0.089: v5(100.29,34.55) 101,35.27 106.99,35.27 v5(107.23,35.02)
N56451042: length 10
  IN1 w0.06: 109.37,38.33 108.99,38.33 108.9,38.24 108.64,38.24 108.45,38.05 v1(108.45,38.05)
  IN1 w0.076: 109.37,38.33 109.51,38.19 109.94,38.19 110.69,37.44 112.76,37.44 113.21,36.99 113.24,36.99 113.39,36.84 113.39,36.56 113.52,36.43 113.52,35.69 113.26,35.43 113.05,35.43 v2(113.02,35.4)
  IN2 w0.058: v3(112.17,34.51) 112.2,34.53 112.2,34.61 113,35.4 v2(113.02,35.4)
  IN4 w0.058: v5(112.3,33.46) 112.3,33.53 112.05,33.79 112.05,34.33 112.17,34.46 v3(112.17,34.51)
N56454933: length 3.4
  BOTTOM w0.089: U1007.28 135.89,47.72 135.8,47.63 134.86,47.63 134.58,47.91 134.58,48.42 134.43,48.57 R91141.1
N56604556: length 1
  IN2 w0.058: v2(143.42,47.3) 143.42,47.58 v3(143.37,47.63)
  IN4 w0.058: v3(143.37,47.63) 143.39,47.66 v5(143.39,48.26)
N56886955: length 2.9
  TOP w0.089: U6517.D8 123.76,49.84 123.15,49.84 122.63,50.36 122.63,51.24 122.42,51.44 R91179.2
N57277369: length 1.7
  TOP w0.089: U6517.H4 125.84,52.28 126.17,52.62 R90893.1
N57503421: length 2.4
  IN2 w0.058: v3(38.84,4.83) 38.84,4.6 39.11,4.34 v2(39.11,4.04)
  IN4 w0.058: v5(39.3,4.47) 39.2,4.47 v3(38.84,4.83)
  BOTTOM w0.089: CON16.43 v5(39.3,4.47)
N57744014: length 3.4
  TOP w0.076: U6525.11 37.2,27.87 36.95,27.63 36.72,27.63 36.46,27.36 36.27,27.36 36.15,27.48 36.15,27.59 36.3,27.74 C333.2 36.3,28.2 36.15,28.35 36.15,28.5 36.26,28.61 R443.2
N57744016: length 3.7
  TOP w0.076: U6525.12 37.2,27.22 36.96,27.47 36.78,27.47 36.52,27.21 36.2,27.21 36,27.41 36,27.59 35.85,27.74 C333.1 35.85,28.2 36,28.35 36,28.5 35.9,28.61 R442.2
N57744064: length 4.8
  TOP w0.076: U6525.14 39.54,25.71 39.78,25.46 39.78,25.2 39.96,25.03 41.85,25.03 42.15,25.32 42.26,25.32 42.4,25.18 C10385.2 43.04,25.18 R90488.2
N57744066: length 4.6
  TOP w0.076: R90489.2 43.04,25.63 C10385.1 42.42,25.63 42.26,25.47 42.09,25.47 41.79,25.18 40.03,25.18 39.94,25.27 39.94,25.41 40.19,25.66 U6525.15
N57744104: length 4
  TOP w0.076: R90490.2 43.67,29.37 43.67,29.19 C10386.2 43.67,28.89 43.67,28.03 43.13,27.49 42.76,27.49 42.49,27.22 U6525.1
N57744106: length 3.8
  TOP w0.076: R90491.2 43.52,29.37 43.52,29.19 C10386.1 43.52,28.89 43.52,28.09 43.07,27.64 42.79,27.64 42.55,27.87 U6525.2
N57744144: length 2.7
  TOP w0.076: R90492.2 12.84,21.17 12.76,21.09 12.76,20.81 12.91,20.66 C10387.2 12.91,20.35 12.74,20.18 12.74,19.89 12.82,19.81 12.92,19.81 12.99,19.73 U6524.11
N57744146: length 2.7
  TOP w0.076: U6524.12 12.34,19.73 12.42,19.81 12.52,19.81 12.59,19.89 12.59,20.21 12.46,20.35 C10387.1 12.46,20.66 12.61,20.81 12.61,21.09 12.53,21.17 R90493.2
N57744176: length 4.5
  TOP w0.076: U6524.14 10.53,17.27 10.45,17.2 10.45,17.1 10.38,17.02 10.09,17.02 9.89,16.82 9.89,15.59 10.07,15.41 10.07,15.17 9.92,15.02 C10388.2 9.92,14.49 9.76,14.33 R90494.2
N57744178: length 4.2
  TOP w0.076: R90495.2 10.52,14.33 10.37,14.49 C10388.1 10.37,15.02 10.22,15.17 10.22,15.47 10.04,15.65 10.04,16.76 10.16,16.87 10.38,16.87 10.63,16.62 U6524.15
N57744224: length 2.7
  TOP w0.076: U6524.1 12.34,14.16 12.42,14.08 12.52,14.08 12.59,14.01 12.59,13.9 12.46,13.77 C10389.2 12.46,13.29 12.61,13.14 12.61,12.8 12.53,12.73 R90497.2
N57744226: length 2.7
  TOP w0.076: U6524.2 12.99,14.16 12.92,14.08 12.82,14.08 12.74,14.01 12.74,13.9 12.91,13.74 C10389.1 12.91,13.31 12.76,13.16 12.76,12.8 12.84,12.73 R90496.2
N57744256: length 3.9
  TOP w0.076: R90498.2 118.02,13.49 118.02,13.7 C10390.2 117.87,14.08 118.02,14.24 118.02,15.19 118.26,15.42 118.45,15.42 118.53,15.51 118.53,15.61 118.61,15.68 U6526.11
N57744258: length 3.6
  TOP w0.076: U6526.12 118.61,15.03 118.53,15.11 118.53,15.17 118.43,15.27 118.32,15.27 118.18,15.13 118.18,14.22 118.32,14.08 C10390.1 118.17,13.7 118.17,13.49 R90499.2
N57744304: length 3.8
  TOP w0.076: U6526.14 121.07,13.22 121.15,13.15 121.24,13.15 121.32,13.07 121.32,12.4 120.81,11.89 120.71,11.89 120.56,12.04 C10391.2 120.25,12.04 120.1,11.89 119.9,11.89 119.82,11.97 R90500.2
N57744306: length 4.1
  TOP w0.076: R90501.2 119.82,11.64 119.92,11.74 120.15,11.74 120.3,11.59 C10391.1 120.61,11.59 120.76,11.74 120.88,11.74 121.47,12.34 121.47,13.07 121.55,13.15 121.64,13.15 121.72,13.22 U6526.15
N57744336: length 2.6
  TOP w0.076: R90503.2 125.49,15.22 125.41,15.3 125.13,15.3 124.98,15.15 C10392.2 124.67,15.15 124.53,15.28 124.33,15.28 124.26,15.21 124.26,15.11 124.18,15.03 U6526.1
N57744338: length 2.6
  TOP w0.076: R90502.2 125.49,15.53 125.41,15.45 125.13,15.45 124.98,15.6 C10392.1 124.67,15.6 124.5,15.43 124.33,15.43 124.26,15.51 124.26,15.61 124.18,15.68 U6526.2
N57744932: length 4.1
  TOP w0.076: R90540.2 49.46,39.45 49.51,39.5 49.51,39.78 49.36,39.93 C10400.2 49.36,40.34 49.56,40.54 49.56,41.97 49.71,42.11 49.86,42.11 50.1,42.35 U6530.11
N57744934: length 3.9
  TOP w0.076: U6530.12 50.11,41.7 49.85,41.96 49.77,41.96 49.72,41.9 49.72,40.52 49.81,40.42 C10400.1 49.81,39.91 49.67,39.76 49.67,39.5 49.72,39.45 R90539.2
N57744959: length 6.2
  TOP w0.076: U6530.14 52.34,39.89 52.41,39.82 52.51,39.82 52.59,39.74 52.59,39.63 52.51,39.55 51.66,39.55 50.96,38.85 50.96,37.76 50.66,37.46 50.66,37.34 50.46,37.14 C10401.2 50.46,36.88 50.61,36.73 50.61,36.4 50.53,36.32 R90541.2
N57744961: length 6.1
  TOP w0.076: U6530.15 52.99,39.89 52.91,39.82 52.81,39.82 52.74,39.74 52.74,39.57 52.57,39.4 51.72,39.4 51.11,38.79 51.11,37.7 50.81,37.39 50.81,37.34 50.91,37.25 C10401.1 50.91,36.88 50.76,36.73 50.76,36.4 50.84,36.32 R90542.2
N57744999: length 3.9
  TOP w0.076: U6530.1 55.45,41.7 55.53,41.78 55.53,41.88 55.6,41.95 56.5,41.95 56.68,42.13 56.68,42.4 56.82,42.55 C10402.2 56.82,42.94 56.68,43.08 56.68,43.37 56.83,43.52 R90543.2
N57745009: length 3.7
  TOP w0.076: U6530.2 55.45,42.35 55.53,42.28 55.53,42.18 55.6,42.1 56.43,42.1 56.52,42.2 56.52,42.42 56.37,42.57 C10402.1 56.37,42.99 56.52,43.14 56.52,43.37 56.37,43.52 R90544.2
N57745825: length 2.6
  BOTTOM w0.076: U6539.1 122.95,59.48 122.63,59.8 122.44,59.8 122.39,59.75 C10434.1 122.1,59.65 121.95,59.8 121.65,59.8 121.59,59.75 R90717.1
N57745829: length 2.4
  BOTTOM w0.076: R90718.1 121.59,60 121.65,59.95 121.95,59.95 122.1,60.1 C10434.2 122.43,59.96 122.75,59.96 122.92,60.13 U6539.2
N57745845: length 2.5
  BOTTOM w0.076: R90715.1 130.74,56.62 130.69,56.67 130.69,56.98 130.84,57.13 C10435.1 130.84,57.49 130.72,57.61 130.72,57.82 130.98,58.08 U6538.1
N57745857: length 2.5
  BOTTOM w0.076: U6538.2 130.33,58.05 130.56,57.82 130.56,57.61 130.39,57.44 C10435.2 130.39,57.13 130.54,56.98 130.54,56.67 130.49,56.62 R90716.1
N57745883: length 2.7
  BOTTOM w0.076: U6540.1 118.56,31.29 118.37,31.48 118.05,31.48 117.89,31.33 C10436.1 117.56,31.48 117.45,31.48 117.22,31.25 117.01,31.25 116.92,31.17 R90719.1
N57745895: length 2.6
  BOTTOM w0.076: U6540.2 118.48,31.94 118.18,31.64 118.04,31.64 117.89,31.78 C10436.2 117.56,31.63 117.38,31.63 117.16,31.41 117.02,31.41 116.92,31.51 R90720.1
N57747685: length 1.6
  BOTTOM w0.089: Q80.3 40.34,13.13 40.24,13.04 39.73,13.04 39.64,12.95 Q80.6
N57747756: length 1.6
  TOP w0.089: Q81.6 40.08,5.69 39.99,5.59 39.99,5.09 39.89,4.99 Q81.3
N57851870: length 2.1
  BOTTOM w0.089: U6548.1 48.58,17.77 C10644.2 48.21,17.1 47.98,16.87 R90912.2
N57966251: length 5.2
  TOP w0.089: v2(109.36,34.32) 109.38,34.35 SH8101.1
  IN2 w0.254: v3(108.57,36.56) 108.42,36.71 v8(108.42,36.85) ; v2(109.36,34.32) 109.13,34.55 v3(108.82,34.55) 108.62,34.55 v2(108.44,34.38)
  IN4 w0.381: v3(108.57,36.56) 108.69,36.56 108.7,36.55 108.74,36.55 109.2,36.09 109.49,36.09 109.85,35.73 109.85,35.19 109.22,34.55 v3(108.82,34.55)
N57966255: length 7.9
  TOP w0.089: U2001.M3 108.42,36.45 108.15,36.17 108.15,35.92 108.34,35.73 108.34,35.48 108.48,35.34 108.48,34.81 108.77,34.52 108.77,34.06 108.61,33.9 C8101.1 108.34,33.78 108.43,33.69 109.1,33.69 v1(109.33,33.46) ; v1(111.54,32.39) 111.57,32.42 111.57,32.71 111.74,32.89 L6904.1
  IN1 w0.076: v1(109.33,33.46) 109.96,32.82 111.41,32.82 111.54,32.7 v1(111.54,32.39)
N58126390: length 3.8
  IN2 w0.058: v3(45.4,5.04) 45.55,5.04 45.88,4.71 46.46,4.71 v2(46.59,4.58)
  IN4 w0.058: v5(44.94,5.26) 45.17,5.04 v3(45.4,5.04)
  BOTTOM w0.089: v5(44.94,5.26) 44.5,4.82 CON16.17
N58126933: length 1.9
  TOP w0.203: R323.2 R90587.1 41.48,7.27 41.58,7.17 Q727.1
N58199130: length 1.2
  BOTTOM w0.089: U6548.7 50.8,17.77 CHG_QONB_MTK.1
N58200688: length 1.3
  BOTTOM w0.089: U6548.6 50.66,18.17 BATT_DISABLE_ODL_MTK.1
N58463958: length 2.8
  TOP w0.089: U6554.1 37.81,11.44 38.49,12.12 C10538.1 38.47,12.66 R90988.1
N58463974: length 1.4
  TOP w0.203: R90987.2 40.93,9.38 40.75,9.56 U6554.4
N58586333: length 7.6
  TOP w0.089: R90758.1 93.84,36.2 93.45,36.58 v1(93.43,36.58)
  IN1 w0.06: v7(89.03,38.36) 89.23,38.16 90.32,38.16 90.86,38.71 91.19,38.71 91.27,38.79 92.97,38.79 93.43,38.33
  IN1 w0.076: 93.43,38.33 93.48,38.28 93.48,36.99 93.53,36.94 93.53,36.68 v1(93.43,36.58)
N59253824: length 1.4
  TOP w0.089: R90991.2 46.34,9.66 46.29,9.61 U6553.4
N59275044: length 1.9
  TOP w0.089: U6522.14 114.9,57.09 R90465.2 C10378.1
N59275078: length 1.1
  TOP w0.089: U6522.15 114.5,56.64 114.23,56.91 R91031.2
N60013740: length 5.7
  TOP w0.089: Y1.3 19.76,16.1 19.85,16.19 20.4,16.19 20.66,15.93 C45.1 21.9,15.93 R17.2 22.36,16.38 22.36,17.12 22.76,17.52 U1.44
N60013744: length 6.5
  TOP w0.089: U1.43 22.82,17.92 22.11,17.21 22.11,16.91 R17.1 21.48,16.7 21.37,16.6 C44.1 20.66,16.6 20.51,16.44 19.03,16.44 Y1.1
N60013813: length 1.4
  TOP w0.089: U1.11 v2(28.63,27.61)
  IN2 w0.058: v2(28.63,27.61) v3(28.63,27.28)
  IN4 w0.058: v3(28.63,27.28) v5(28.63,26.96)
N60013922: length 2.1
  TOP w0.089: U1.22 24.23,27.75 24.36,27.87 24.36,28.49 24.34,28.51 R10.1
N60013924: length 2
  TOP w0.089: v2(22.49,20.02) 22.59,19.92 U1.38
  IN2 w0.058: v3(23.2,19.97) 23.17,20 22.54,20 22.51,20.02 v2(22.49,20.02)
  IN4 w0.058: v5(23.35,19.67) 23.35,19.82 v3(23.2,19.97)
N60014085: length 1.4
  TOP w0.203: U1.56 28.63,15.54 R3.1
N60014313: length 1.6
  TOP w0.089: v2(25.29,15.82) 25.43,15.95 U1.48
  IN2 w0.058: v3(25.03,15.55) v2(25.29,15.82)
  IN4 w0.058: v5(25.03,15.17) v3(25.03,15.55)
N60014315: length 1.6
  TOP w0.089: U1.49 25.83,15.92 25.76,15.86 v2(25.76,15.78)
  IN2 w0.058: v2(25.76,15.78) 25.76,15.6 v3(25.64,15.47)
  IN4 w0.058: v5(25.76,15.15) 25.76,15.35 v3(25.64,15.47)
N60014348: length 1.4
  TOP w0.089: R15.2 24.24,15.8 24.23,15.81 U1.45
N60384112: length 3.8
  TOP w0.254: R91314.1 58.18,3.79 58.05,3.91 C10620.1 R91088.1 56.5,3.97 56.11,4.36 56.11,4.57 56.28,4.75 U12.8
N60385347: length 3
  TOP w0.203: R91188.2 59.85,7.78 60.61,7.78 R91087.1 60.61,7.18 v2(60.64,7.15)
  IN2 w0.203: v2(61.74,6.05) v2(60.64,7.15)
N60385350: length 14.2
  TOP w0.089: R91116.2 54.8,12.88 55.15,12.53 57.84,12.53 58.42,11.96 60.22,11.96 60.56,12.3 61.9,12.3 62.05,12.14 62.05,10.77 Q762.2 61.99,10.39 62.21,10.17 62.21,8.72 61.96,8.46 61.65,8.46 61.44,8.25 R91092.2 61.12,8.01 60.9,8.23 R91087.2
N60385391: length 2.2
  TOP w0.203: v2(58.15,7.78) 58.16,7.77 R91189.2
  IN2 w0.203: v2(58.15,7.78) 58.15,7.75 v2(57.09,6.7)
N60385409: length 2.8
  TOP w0.089: Q763.2 57.1,7.82 R91093.2 57.47,7.7 57.64,7.87 57.64,8.05 57.82,8.23 R91089.2 58.06,8.71 R91115.2
N60471943: length 1.1
  TOP w0.089: U6574.4 150.46,36.69 150.51,36.74 R91094.2
N60563932: length 3.9
  TOP w0.089: U6546.11 68.44,24.92 68.36,24.85 68.36,24.47 68.44,24.39 68.44,24.01 68.46,23.98 C10461.1 68.23,23.7 68.16,23.78 R90746.1 68.22,23.27 Y2.3
N60563934: length 7.3
  TOP w0.089: Y2.1 67.22,22 67.22,23.53 66.96,23.78 R90746.2 66.53,23.78 66.43,23.68 C10462.1 66.15,24.13 66.38,24.36 67.7,24.36 67.94,24.6 U6546.10
N60565652: length 4.3
  TOP w0.089: U2001.M2 108.54,35.94 108.54,35.6 108.72,35.42 108.72,34.91 109.03,34.61 109.03,34.19 109.23,33.99 109.47,33.99 109.69,33.77 109.69,33.25 109.56,33.13 109.3,33.13 109.15,32.97 SH8102.1
N60574431: length 2.8
  TOP w0.203: R90985.1 60.04,13.43 60.33,13.14 C10534.1 61.14,13.14 61.45,12.84 U6531.A1
N60577846: length 1.1
  TOP w0.089: Q730.3 Q768.3
N60577867: length 1.1
  TOP w0.089: Q731.3 Q767.3
N60586308: length 1.4
  TOP w0.089: R91118.2 22.74,43.29 22.69,43.24 U6555.4
N60586345: length 1.5
  TOP w0.089: U6555.3 22.58,42.84 22.87,42.55 R91117.2
N60586415: length 5.3
  TOP w0.075: U1001.AE2 80.81,34.14 80.54,34.14 80.4,34.28 80.16,34.28 79.82,33.93
  TOP w0.089: 79.82,33.93 79.71,33.93 79.52,33.75 79.22,33.75 79.04,33.93 77.97,33.93 R91217.1 77.44,34.9 R90462.1
N60586427: length 5
  TOP w0.075: 79.66,32.83 79.99,33.16 79.99,33.43 80.51,33.95 81.01,33.95 U1001.AF2
  TOP w0.089: R91218.1 77.44,33.39 77.66,33.17 R90461.1 79.35,32.91 79.45,32.81 79.64,32.81 79.66,32.83
N60586444: length 6.9
  IN1 w0.06: v7(81.44,35.18) 81.44,35.03 80.86,34.45 80.09,34.45
  IN1 w0.076: v1(78.47,29.95) 78.47,30.55 79.06,31.14 79.06,32.64 79.84,33.42 79.84,34.19 80.09,34.45
N60699731: length 2.4
  TOP w0.089: U6546.22 71.32,30.67 71.43,30.79 R91098.1
N60699944: length 2.5
  TOP w0.089: R91097.2 70.7,31.25 70.57,31.38 69.56,31.38 69.44,31.25 U6546.23
N60700030: length 4.2
  TOP w0.089: U6546.8 65.56,25.47 65.24,25.15 R90741.1
N60700076: length 1.5
  TOP w0.089: HUB_TEST.1 71.86,28.07 U6546.18
N60700101: length 1.3
  TOP w0.089: U6546.26 67.94,31.6 HUB_SDA.1
N60721677: length 4.2
  TOP w0.127: R90763.2 R90333.2 9.63,36.58 9.61,36.61 ESD6204.2 9.61,37.42 10,37.81 CON6201.6
N60724657: length 49
  TOP w0.203: R90334.2 14.47,33.5 14.49,33.48 v1(14.77,33.48)
  TOP w0.254: R90761.2 7.53,26.04 7.28,26.29 v2(6.71,26.29)
  IN1 w0.254: v2(14.1,25.46) 14.1,25.67 15.2,26.76 15.2,29.19 14.26,30.13 14.26,30.77 13.72,31.3 13.72,32.87 14.33,33.48 v1(14.77,33.48) 15.15,33.86 15.15,34.96 16.11,35.92 v2(16.11,47.38)
  IN2 w0.254: v2(14.1,25.46) 13.95,25.46 12.1,23.6 10.28,23.6 7.6,26.29 v2(6.71,26.29) ; CON6201.3 6.14,49.84 14.64,49.84 16.11,48.37 v2(16.11,47.38)
N60727876:
  vias: v6(9,57.61) v6(9.08,59.44) v6(9.72,57.52) v6(9.79,59.44) v6(9.92,55.46) v6(10.58,55.18) v6(20.1,48.75) v6(20.13,48.04) v6(20.84,47.91) v6(20.89,48.62) v6(21.55,47.89) v6(21.65,48.6)
N60821505: length 4.1
  TOP w0.089: TP9143.1 108.19,33.53 v1(108.01,33.53)
  IN1 w0.06: v7(107.62,36.85) 107.62,36.74 107.7,36.67 107.7,36.34 107.75,36.29 107.75,34.8 107.93,34.62
  IN1 w0.076: v1(108.01,33.53) 108.01,33.94 107.93,34.02 107.93,34.62
N60836746: length 3.9
  TOP w0.089: v1(43.16,48.06) 43.16,48.2 43.05,48.32 42.22,48.32 42.05,48.14 Q776.3 ; Q776.6 42.75,46.7 v1(42.99,46.46)
  IN1 w0.076: v1(42.99,46.46) 42.9,46.55 42.9,47.83 43.14,48.06 v1(43.16,48.06)
N60836749: length 1.5
  TOP w0.089: Q777.3 46.33,47.23 46.19,47.38 45.75,47.38 45.63,47.5 Q777.6
N60837599: length 1.5
  TOP w0.089: Q778.3 50.45,47.98 50.25,47.78 50.25,47.37 50.16,47.28 Q778.6
N60842437: length 1.6
  TOP w0.089: Q779.6 54.09,47.28 54.21,47.4 54.21,47.86 54.33,47.98 Q779.3
N61047769: length 1.5
  BOTTOM w0.381: CON15.6 95.7,9.78 v6(95.89,9.58)
N61065144: length 1
  BOTTOM w0.089: Q3.4 24.27,19.14 24.35,19.21 R90783.2
N61065146: length 1.6
  BOTTOM w0.089: Q3.6 24.97,18.16 24.87,18.07 24.42,18.07 24.27,17.92 Q3.3
N61065214: length 1.2
  BOTTOM w0.089: R90784.2 26.93,18.68 26.88,18.63 26.88,18.34 26.96,18.26 Q4.4
N61065216: length 1.5
  BOTTOM w0.089: Q4.3 26.54,18.26 26.63,18.17 26.63,17.76 26.83,17.56 Q4.6
N61071962: length 3.7
  TOP w0.089: U6559.46 136.89,14.48 136.38,13.98 136.38,12.96 TP9146.1
N61071965: length 3.5
  TOP w0.089: U6559.45 136.9,14.88 136.13,14.1 136.13,13.21 135.75,12.83 R91214.1
N61071968: length 3.1
  TOP w0.089: R91213.1 135.75,13.6 135.87,13.72 135.87,14.23 136.92,15.28 U6559.44
N61071971: length 2.8
  TOP w0.089: U6559.43 136.94,15.68 135.62,14.36 TP9149.1
N61072057: length 1.3
  TOP w0.089: U6559.31 140.5,20.13 TP9151.1
N61072060: length 2.8
  TOP w0.089: TP9152.1 141.08,20.96 141.08,19.95 140.9,19.76 U6559.30
N61072172: length 2.2
  TOP w0.089: R91160.1 51.82,18.17 52.59,17.41 U124.A5
N61120487: length 59.3
  TOP w0.254: v2(98.61,14.94) v2(90.99,14.94)
  IN2 w0.254: v2(90.99,14.94) 90.33,14.94 89.37,15.91 87.44,15.91 v3(87.03,15.5) ; v3(103.17,17.54) 103.23,17.48 103.23,16.57 103.01,16.34 99.02,16.34 98.61,15.93 v2(98.61,14.94) 99.27,14.94 99.42,15.09 100.28,15.09 v2(101.15,14.23)
  IN4 w0.254: v3(103.17,17.54) 102.78,17.94 v5(102.78,17.94) ; v3(87.03,15.5) 86.9,15.5 v5(86.39,14.99)
  IN5 w0.254: v5(62.21,22.23) 63.71,23.73 68.59,23.73 68.94,23.37 68.94,21.22 v5(69.2,20.96)
  BOTTOM w0.254: Q798.2 62.3,23.76 R91330.2 R91269.2 61.84,22.6 v5(62.21,22.23) ; v5(102.78,17.94) 102.72,17.89 101.96,17.89 101.91,17.94 U6569.7 ; v5(69.2,20.96) 69.71,20.96 70.09,20.58 72.13,20.58 72.67,20.05 76.92,20.05 79.03,17.94 79.03,15.91 80.55,14.38 85.78,14.38 v5(86.39,14.99)
N61120556: length 2.3
  BOTTOM w0.089: PP1800_ALW_PG.1 99.93,20.83 98.76,19.66 U6569.4
N61120560: length 14
  IN3 w0.254: v3(91.3,16.9) 91.3,16.59 92.57,15.32 99.55,15.32 101.56,17.33 101.56,18.19 101.81,18.45 v6(102.27,18.45)
  IN4 w0.254: v5(90.94,16.9) v3(91.3,16.9)
N61126400: length 5.9
  IN4 w0.254: v5(102.8,17.19) 102.4,16.8 99.27,16.8 98.43,17.63 98.43,18.4 v5(98.63,18.59)
N61126405: length 3.3
  BOTTOM w0.381: C10630.1 100.13,16.06 U6569.8
N61132531: length 8.8
  BOTTOM w0.254: Q782.2 15.35,32.38 15.35,31.58 16.09,30.84 Q781.2 15.38,30.12 15.38,29.14 14.74,28.5 Q780.3 14.74,27.54 14.51,27.32 R91323.2 15.24,26.41 R90870.1
N61132598: length 39.4
  IN3 w0.089: v3(14.71,30.71) 14.71,31.06 14.62,31.15 14.15,31.15 13.91,31.38 13.91,33.46 16.41,35.95 20.46,35.95 21.4,36.89 23.68,36.89 24.28,37.48 24.55,37.48 25.1,38.04 25.1,38.4 23.74,39.76 23.74,42.79 v3(23.5,43.03)
  IN4 w0.056: v3(23.5,43.03) v5(23.5,43.39) ; v5(14.71,30.33) v3(14.71,30.71)
  BOTTOM w0.071: R90744.1 10.83,50.84 10.9,50.76 10.9,50.45 11.15,50.2 14.7,50.2 21.08,43.82 23.58,43.82 23.68,43.72 23.68,43.62 23.5,43.44 v5(23.5,43.39)
N61132650: length 39.4
  IN3 w0.089: v3(14.71,32.26) 14.71,31.57 14.53,31.39 14.25,31.39 14.16,31.48 14.16,33.36 16.51,35.71 20.56,35.71 21.5,36.65 23.78,36.65 24.38,37.24 24.65,37.24 25.34,37.94 25.34,38.5 23.99,39.86 23.99,42.88 v3(24.14,43.03)
  IN4 w0.056: v3(24.14,43.03) v5(24.14,43.36) ; v5(14.71,32.62) v3(14.71,32.26)
  BOTTOM w0.071: v5(24.14,43.36) 24.09,43.36 23.9,43.55 23.9,43.81 23.67,44.04 21.17,44.04 14.79,50.43 11.25,50.43 11.12,50.55 11.12,50.71 11.25,50.84 R90745.1
N61181427: length 2.9
  TOP w0.089: R91028.2 30.72,45.73 30.84,45.6 R91029.1 31,44.87 U6558.B3
N61184076: length 1.8
  TOP w0.089: U6558.A3 32.43,44.08 32.02,44.49 R91171.2
N61196473: length 1.6
  TOP w0.089: U6517.H6 124.84,53.03 124.85,53.04 R91174.1
N61196524: length 2.5
  TOP w0.089: U6517.G4 126.09,51.68 126.09,52.2 126.93,53.04 R91175.1
N61196760: length 3.1
  TOP w0.089: U6517.A2 126.84,48.16 127.49,47.5 128.17,47.5 128.86,46.81 R90868.2
N61211362: length 5.6
  BOTTOM w0.089: CON16.47 38.5,4.42 37.96,4.96 35.16,4.96 TP9154.1
N61211380: length 4.7
  BOTTOM w0.089: CON16.49 38.02,4.39 37.83,4.58 34.4,4.58 TP9155.1
N61211412: length 10.1
  BOTTOM w0.089: CON16.19 44.1,5.57 45.03,6.49 48.98,6.49 49.58,7.09 51.48,7.09 TP9157.1
N61211428: length 8.2
  BOTTOM w0.089: TP9158.1 51.67,4.58 50.48,5.77 46.57,5.77 46.1,5.3 CON16.9
N61211444: length 8.1
  BOTTOM w0.089: TP9159.1 51.38,6.01 46.46,6.01 45.7,5.24 CON16.11
N61211467: length 11.3
  BOTTOM w0.089: TP9160.1 52.08,8.69 52.08,6.76 51.57,6.25 46.05,6.25 45.3,5.5 CON16.13
N61211489: length 3.9
  BOTTOM w0.089: CON16.50 35.27,8.2 TP9161.1
N61211505: length 4.2
  BOTTOM w0.089: TP9162.1 36.28,11.21 38.5,8.99 CON16.48
N61211521: length 5.6
  BOTTOM w0.089: CON16.46 38.9,8.97 36.94,10.93 36.94,11.44 36,12.38 TP9163.1
N61211537: length 4
  BOTTOM w0.089: CON16.44 39.3,9.58 R91181.1
N61211553: length 3.5
  BOTTOM w0.089: CON16.26 42.9,9.9 43.7,10.71 TP9165.1
N61211569: length 5
  BOTTOM w0.089: CON16.28 42.5,10.01 43.24,10.75 43.24,12.22 TP9166.1
N61211585: length 5.9
  BOTTOM w0.089: CON16.30 42.1,10.12 42.99,11 42.99,13.14 TP9167.1
N61211601: length 4.8
  BOTTOM w0.089: CON16.10 46.1,9.28 47.43,10.61 TP9168.1
N61211617: length 3.5
  BOTTOM w0.089: CON16.12 45.7,9.58 46.8,10.67 TP9169.1
N61212041: length 4.4
  TOP w0.089: R91187.2 120.81,49.1 v2(120.84,49.08)
  IN2 w0.058: v2(120.84,49.08) 120.94,49.08 120.99,49.13 122.59,49.13 122.69,49.23 123.07,49.23 123.76,49.92 v2(124.34,49.92)
N61212164: length 1.4
  BOTTOM w0.089: U6548.4 49.64,19.18 49.46,19.36 49.16,19.36 TP9170.1
N61235164: length 1.8
  TOP w0.089: U6528.4 129.65,16.32 130.5,15.47 R90537.2
N61235178: length 1.7
  TOP w0.089: R90520.2 129.78,15.85 129.25,16.38 U6528.3
N61235179: length 1.3
  TOP w0.089: C10396.1 129.25,19.83 U6528.12
N61235182: length 2.3
  TOP w0.089: R90512.2 131.13,15.8 130.51,15.8 130.05,16.26 U6528.5
N61235183: length 1.3
  TOP w0.089: U6528.10 130.05,19.48 130.41,19.84 C10395.1
N61283122: length 2
  TOP w0.089: U6.23 123.7,34.91 123.37,35.25 123.11,35.25 122.7,35.66 R91191.2
N61285156: length 1.5
  TOP w0.089: C10453.1 119.63,34.54 120.51,33.66 R90740.1
N61285894: length 3.2
  TOP w0.089: R405.1 121.07,34.54 121.82,33.79 121.82,33.26 122.09,32.99 U6.27
N61286104: length 3.6
  TOP w0.089: R538.2 120.6,36.36 121.15,35.82 R537.2 121.27,35.81 122.7,34.38 U6.25
N61287435: length 2.4
  TOP w0.178: U6.31 121.84,31.39 120.84,30.38 C10451.1
N61287510: length 4.7
  TOP w0.203: R91194.1 121.57,27.92 121.67,27.81 C10666.1 122.14,28.11 123.12,29.09 123.4,29.09 124.1,29.79 U6.3
N61290911: length 1.6
  TOP w0.089: R91195.2 121.57,32.37 121.75,32.19 U6.29
N61302308: length 2.3
  TOP w0.089: U6559.33 139.7,19.63 139.33,20 R91205.1 R91203.1
N61302311: length 2.4
  TOP w0.089: R91202.1 R91204.1 138.64,20.23 139.3,19.56 U6559.34
N61354736: length 2.2
  BOTTOM w0.089: R91057.1 30.06,39.03 28.81,40.27 U6577.C2
N61388546: length 1
  TOP w0.089: Q734.3 Q732.3
N61404476: length 3.1
  TOP w0.089: U6517.H7 124.59,52.18 124.59,53.15 124.44,53.31 124.44,54.24 124.16,54.52 R91173.1
N61404641: length 2.8
  TOP w0.089: U6517.B7 124.57,48.69 124.57,47.96 123.4,46.79 R91209.2
N61407341: length 1.8
  TOP w0.089: U6404.5 142.74,33.27 142.73,33.28 C6404.2 R90264.1
N61407398: length 3
  TOP w0.089: U6404.1 145.26,34.39 145.91,35.03 R90416.2 R90417.2 R91224.2
N61407402: length 2.1
  TOP w0.089: U6404.13 146.03,32.77 146.26,33 R91222.2 R91219.2
N61407435: length 2.2
  TOP w0.089: R91220.2 R91221.2 146.44,33.69 146.03,33.27 U6404.14
N61407437: length 2.6
  TOP w0.089: U6404.8 143.76,31.01 143.87,30.89 C10446.1 C6401.1 R7701.1
N61407473: length 2.2
  TOP w0.089: U6404.12 146.03,32.27 146.44,31.85 R90418.1 R91223.2
N61407509: length 1.9
  TOP w0.089: R90568.2 R90569.2 143.72,34.71 143.76,34.67 U6404.4
N61407519: length 1.7
  TOP w0.089: U6404.9 144.26,30.86 TP9055.1
N61505227: length 7.4
  TOP w0.089: R91226.2 25.24,48.77 26.14,48.77 26.45,48.47 Q790.3 26.67,46.81 26.91,47.05 28.44,47.05 28.56,47.16 28.56,47.77 R91250.1
N61527186: length 1.2
  TOP w0.089: R940.1 23.12,28.12 23.05,28.2 U93.25
N61543208: length 1.7
  TOP w0.089: U6559.12 142.9,12.16 143.11,11.94 TP9175.1
N61557721: length 168.3
  TOP w0.089: D7.1 4.79,33.52 v2(4.81,33.54) ; v2(133.56,12.91) 134.15,13.49 134.15,16.57 134.85,17.27 R91161.1
  IN2 w0.058: v2(4.81,33.54) v3(4.81,33.15) ; v2(133.56,12.91) 133.1,12.91 132.8,13.21 129,13.21 128.45,12.66 127.4,12.66 127.14,12.41 124.35,12.41 121.15,9.21 119.57,9.21 118.55,8.19 91.92,8.19 88.91,11.2 86.45,11.2 85.48,12.17 81.33,12.17 79.84,11.61 78.52,11.04 74.9,7.41 70.31,7.41 69.52,6.62 67.33,6.62 66.69,5.98 66.69,4.71 v3(66.12,4.15)
  IN3 w0.102: v3(66.12,4.15) 65.78,4.15 64.71,3.08 62.59,3.08 62.44,2.93 59.07,2.93 58.64,2.5 21.34,2.5 16.77,7.07 16.55,7.07 13.53,10.09 10.78,10.09 9.29,11.58 9.29,21.27 8.38,22.18 4.99,22.18 4.31,22.87 4.31,31.35 4.81,31.86 v3(4.81,33.15)
N61557738: length 22.7
  TOP w0.089: D7.4 4.06,36.33 4.06,36.57 v2(4.43,36.94)
  IN2 w0.058: v2(4.43,36.94) 4.71,36.94 v3(4.78,36.86)
  IN4 w0.058: v3(4.78,36.86) 4.96,36.68 v5(5.09,36.68)
  BOTTOM w0.089: R91327.2 19.3,42.3 R91326.2 18.3,43.29 16.72,43.29 16.55,43.12 16.55,42.58 16.88,42.25 16.88,39.2 14.7,37.02 12.99,37.02 12.78,36.81 11.88,36.81 11.82,36.75 5.16,36.75 v5(5.09,36.68)
N61557740: length 168.7
  TOP w0.089: R91162.1 134.4,15.81 134.4,13.06 v2(134.17,12.83)
  IN2 w0.058: v2(134.17,12.83) 133.92,12.83 133.69,12.6 133.11,12.6 132.72,12.99 129.07,12.99 128.54,12.45 127.49,12.45 127.21,12.18 124.42,12.18 121.24,9 119.66,9 118.64,7.97 91.84,7.97 88.84,10.97 86.38,10.97 85.39,11.96 81.37,11.96 79.92,11.41 78.64,10.86 74.97,7.19 70.39,7.19 69.61,6.41 67.42,6.41 66.9,5.9 66.9,4.32 v3(66.73,4.15) ; v2(4.37,34.49) v3(4.74,34.49)
  IN3 w0.102: v3(66.73,4.15) 66.73,4.37 66.51,4.6 65.8,4.6 64.58,3.38 62.47,3.38 62.31,3.23 58.94,3.23 58.51,2.8 21.47,2.8 16.9,7.37 16.68,7.37 13.65,10.39 10.91,10.39 9.6,11.7 9.6,21.4 8.51,22.49 5.12,22.49 4.61,22.99 4.61,31.23 5.29,31.91 5.29,33.94 v3(4.74,34.49)
N61557753: length 168.9
  TOP w0.089: v2(134.6,12.81) 134.68,12.88 134.68,14.18 134.85,14.35 R91163.1
  IN2 w0.058: v2(134.6,12.81) 134.32,12.53 133.91,12.53 133.78,12.39 133.01,12.39 132.65,12.76 129.14,12.76 128.63,12.24 127.57,12.24 127.28,11.95 124.5,11.95 121.34,8.79 119.75,8.79 118.73,7.76 91.75,7.76 88.77,10.74 86.31,10.74 85.3,11.75 81.41,11.75 80,11.22 78.76,10.69 75.04,6.96 70.45,6.96 69.7,6.2 67.52,6.2 67.13,5.81 67.13,4.41 v3(67.39,4.15) ; v2(4.37,35.39) v3(4.7,35.39)
  IN3 w0.102: v3(4.7,35.39) 5.6,34.49 5.6,31.78 4.92,31.1 4.92,23.14 5.27,22.79 8.72,22.79 9.9,21.61 9.9,11.83 11.03,10.7 13.78,10.7 16.8,7.68 17.03,7.68 21.6,3.1 58.39,3.1 58.82,3.54 62.19,3.54 62.34,3.69 64.46,3.69 65.67,4.91 66.63,4.91 v3(67.39,4.15)
N61558357: length 153.9
  TOP w0.089: v2(4.85,22.79) 4.85,23.46 4.8,23.51 R90861.2 ESD7502.1 4.9,25.25 SW7504.1 SW7504.3
  IN1 w0.076: v1(126.14,10.14) 126.35,9.93 126.35,7.78 v2(125.84,7.27)
  IN2 w0.058: v2(125.84,7.27) 125.75,7.18 124.2,7.18 123.09,6.08 91.05,6.08 88.07,9.05 85.6,9.05 84.59,10.06 81.72,10.06 80.63,9.65 79.73,9.26 75.55,5.09 75.09,5.09 73.02,3.01 68.79,3.01 68.26,2.48 65.44,2.48 64.95,2.98 63.81,2.98 v3(62.64,4.15) ; v2(4.85,22.79) v3(5.39,23.33)
  IN3 w0.102: v3(62.64,4.15) 62.37,4.15 62.06,3.84 58.69,3.84 58.26,3.41 21.73,3.41 17.15,7.98 16.93,7.98 13.91,11 11.16,11 10.21,11.96 10.21,21.75 8.86,23.09 5.62,23.09 v3(5.39,23.33)
N61575845: length 7.3
  BOTTOM w0.089: R91252.2 142.86,30.23 143.14,29.95 J17.16
N61575919: length 8
  BOTTOM w0.089: J17.19 141.94,28.45 C10627.2 R9572.2
N61575998: length 7.3
  BOTTOM w0.089: J17.20 142.2,27.95 R277.2
N61591425: length 15.3
  TOP w0.089: v2(108.14,34.91) 107.98,34.91 107.37,35.52 107.37,35.83 107.62,36.08 U2001.K3
  IN1 w0.076: v1(112.94,26.55) 112.94,28.81 114.03,29.9 v2(114.03,31.35)
  IN2 w0.058: v2(114.03,31.35) 114.03,31.52 113.77,31.78 112.84,31.78 112.23,32.39 110.29,32.39 109.36,33.32 109.24,33.32 108.95,33.61 108.95,33.81 108.72,34.04 108.29,34.04 108.11,34.22 108.11,34.89 v2(108.14,34.91)
N61611889: length 1.9
  TOP w0.089: U6579.B2 70.8,51.81 70.8,53.14 R91230.2
N61628180: length 8.5
  TOP w0.089: TP9177.1 66.43,34.5 66.63,34.3 66.89,34.3 67.17,34.58 67.17,35.44 67.25,35.53 67.25,38.03 67.43,38.21 67.43,39.39 66.06,40.76 U6578.G1
N61628183: length 10.3
  TOP w0.089: TP9178.1 65.21,33.99 66.92,33.99 67.41,34.48 67.41,35.17 67.52,35.29 67.52,37.95 67.67,38.11 67.67,39.49 66.46,40.71 U6578.H1
N61628284: length 6.1
  TOP w0.089: R91231.2 67.01,36.82 67.01,38.13 67.19,38.31 67.19,39.29 66.11,40.37 65.9,40.37 v1(65.69,40.57)
  IN1 w0.076: v1(65.26,41.42) 65.26,41.07 65.69,40.63 v1(65.69,40.57)
N61641304: length 2.4
  TOP w0.089: Q791.2 55.72,37.67 55.35,37.31 R91232.1 54.88,37.17 Q792.3
N61663035: length 0.8
  TOP w0.089: U6580.4 127.37,67.71 127.24,67.57 R91243.2
N61663068: length 1.3
  TOP w0.089: R91244.1 128.5,67.16 128.63,67.28 U6580.1
N61724229: length 8.4
  TOP w0.089: Q790.1 25.95,47.88 26.04,47.78 26.04,46.48 26.18,46.34 26.75,46.34 27.21,46.79 28.61,46.79 29.07,47.25 R91250.2 R91251.1 30.76,46.81 Q795.3
N61744432: length 3.7
  IN1 w0.076: v2(63.7,41.27) 63.79,41.36 63.79,41.61 64,41.82 v1(64.46,41.82)
  IN2 w0.058: v2(63.7,41.27) 63.65,41.32 63.24,41.32 63.2,41.36 v3(63.18,41.36)
  IN4 w0.058: v5(64.24,39.93) 63.89,40.29 63.89,40.95 63.61,41.23 63.31,41.23 v3(63.18,41.36)
N61762735: length 1.3
  BOTTOM w0.254: C10426.1 69.99,19.41 69.96,19.44 PR158.1
N61762831: length 9.4
  BOTTOM w0.254: 72.37,18.4 72.37,19.77 71.97,20.17 65.06,20.17 64.76,20.47 R90667.2
N61762862: length 32.7
  IN5 w0.254: v5(48.55,32.92) 48.16,32.92 47.76,32.52 47.76,28.78 50.45,26.09 50.45,23.67 50.69,23.44 v5(50.86,23.44) ; v5(57.67,19.33) 60.2,19.33 v5(60.82,19.95)
  BOTTOM w0.229: U6570.6 63.63,16.53 63.38,16.77 63.38,17.61 62.71,18.28 R91265.2 62.62,18.91 Q766.3 61.29,19.47 v5(60.82,19.95) 61.07,19.95 61.37,20.25 61.37,21.04 61.06,21.35 R91270.2
  BOTTOM w0.254: v5(50.86,23.44) 51.65,23.44 52.05,23.83 55.18,23.83 57.29,21.72 57.29,20.43 57.67,20.05 v5(57.67,19.33)
N61762927: length 3.2
  BOTTOM w0.089: U6570.7 64.47,17.79 64.32,17.93 63.51,17.93 63.2,18.24 63.2,19.39 PP5000_ALW_PG1.1
N61762975: length 3.9
  BOTTOM w0.254: Q766.1 61.84,20.56 61.98,20.71 63.13,20.71 63.55,21.13 64.76,21.13 R90792.2
N61762994: length 4
  BOTTOM w0.229: U6570.10 65.82,18.02 65.69,18.14 65.61,18.14 65.05,18.7 C10645.1 64.95,19.27 C10694.2 64.63,19.67 64.09,20.22 64.09,20.47 R90667.1
N61763032: length 2.8
  BOTTOM w0.229: U6570.9 65.37,17.85 64.97,18.24 63.64,18.24 63.51,18.37 R90666.1
N61763034: length 0.5
  BOTTOM w0.229: R90666.2 C10645.2
N61763068: length 1.7
  BOTTOM w0.229: PC133.1 66.27,18.3 U6570.11
N61763953: length 1.4
  BOTTOM w0.254: PR263.1 53.7,34.04 53.88,33.86 C10633.1
N61764017: length 9.6
  IN3 w0.229: v6(58.68,32.87) 58.07,33.48 50.6,33.48 v3(49.94,32.82)
  IN4 w0.229: v5(49.59,32.82) v3(49.94,32.82)
N61764234: length 2.7
  BOTTOM w0.229: U6571.10 51.14,31.13 50.53,31.74 C10643.1 50.53,32.17 50.28,32.41 R90675.1
N61764266: length 1.6
  BOTTOM w0.229: U6571.12 52.03,31.03 52.34,31.33 R90677.1
N61764268: length 2.5
  IN4 w0.254: v5(52.3,32.6) 52.21,32.6 51.49,31.88 v5(50.1,31.88)
N61764315: length 2.2
  BOTTOM w0.229: U6571.9 50.68,31.04 50.27,31.45 49.8,31.45 PC137.1
N61765555: length 5.5
  BOTTOM w0.229: U6571.6 49.05,29.71 48.73,30.03 48.73,30.44 48.01,31.15 46.79,31.15 46.4,31.54 R91266.2 47.45,31.83 R91276.2
N61767628: length 2.4
  TOP w0.254: Q797.2 102.72,13.54 R91267.2 R91268.2
N61769349: length 1.7
  BOTTOM w0.254: Q798.3 63.45,21.72 R91270.1
N61796431: length 1.6
  BOTTOM w0.089: Q799.6 63.44,45.88 63.56,46.01 64.04,46.01 64.14,46.1 Q799.3
N61796434: length 1.6
  BOTTOM w0.089: Q800.3 67.36,46.06 67.28,45.98 66.76,45.98 66.66,45.88 Q800.6
N61812172: length 3.1
  BOTTOM w0.254: R91275.1 49.23,33.92 49.01,33.7 R91273.2 48.3,33.7 48.03,33.42 R91274.2 R91276.1
N61830685: length 4.2
  BOTTOM w0.089: Q802.2 44.03,17.82 44.8,17.82 45.19,18.22 45.19,19.11 Q803.3 45.57,19.44 R91278.1
N61830695: length 1.7
  BOTTOM w0.089: Q803.2 42.82,18.94 42.73,19.03 42.65,19.03 C10709.2 R91277.2
N62092946: length 1.6
  TOP w0.254: R91308.1 49.59,31.63 Q804.3
N62093576: length 4.6
  TOP w0.254: R91309.1 50.45,25.96 50.09,26.33 Q806.3 50.86,27.18 50.89,27.21 Q805.2
N62093590: length 1.4
  TOP w0.254: R91310.2 Q805.3
N62183299: length 4.5
  IN5 w0.254: v5(54.56,15.83) 54.44,15.71 54.44,13.2 v5(54.56,13.08) 54.44,12.96 53.65,12.96 53.43,12.74 v5(53.07,12.74)
N62372459: length 3.2
  BOTTOM w0.089: U6582.C1 23.46,40.74 24.06,40.14 25.77,40.14 TP9184.1
N62373890: length 1.3
  BOTTOM w0.089: C10716.2 24.93,41.51 24.7,41.28 U6582.A2
N62374623: length 2.6
  TOP w0.089: U6533.B3 24.98,44.33 24.69,44.04 24.69,43.19 R90603.2
N62374627: length 2.9
  TOP w0.089: U6533.C3 25.04,44.73 24.45,44.14 24.45,43.09 24.72,42.82 R90604.2
N62374648: length 2.2
  IN1 w0.076: v1(25.63,44.33) 25.63,43.85 25.94,43.54 26.43,43.54 v1(26.98,42.99)

## Copper pours and planes (outline as drawn)
AVDD18_SOC on BOTTOM (solid shape): 80.91,44.66 80.91,43.65 80.74,43.49 80.01,43.49 79.35,42.82 79.35,38.71 80.02,38.03 80.02,30.82 78.98,29.78 78.98,28.14 79.17,27.95 80,27.95 81.45,29.39 82.84,29.39 84.18,30.74 85.63,30.74 86.75,29.62 86.75,28.73 86.22,28.2 86.22,24.92 85.33,24.03 79.53,24.03 75.95,27.61 75.95,43.8 76.98,44.82 80.75,44.82
AVDD18_SOC on BOTTOM (solid shape): 95.33,46.92 95.33,44.02 91.71,40.4 91.03,40.4 90.09,39.46 89.93,39.3 89.7,39.3 89.62,39.38 89.62,40.01 89.67,40.07 89.7,40.08 89.79,40.16 89.82,40.28 89.81,40.36 89.77,40.43 89.76,40.46 89.76,40.48 89.78,40.5 90.11,40.83 90.12,40.83 90.22,40.93 90.28,40.93 93.71,44.36 93.71,47.03 93.73,47.05 94.87,47.05 94.89,47.07 95.18,47.07
AVDD18_SOC on BOTTOM (solid shape): 98.1,35.03 98.51,35.03 98.79,34.75 98.79,33.55 98.39,33.15 98.33,33.2 96.88,33.2 95.87,34.22 95.03,34.22 94.76,33.95 94.76,33.9 94.75,33.89 94.75,32.87 94.65,32.77 91.06,32.77 90.9,32.61 90.9,32.53 89.44,31.08 87.87,31.08 87.59,31.35 86.88,31.35 86.42,31.8 86.42,32.42 86.54,32.53 88.35,32.53 90.38,34.56 92.55,34.56 92.9,34.22 93.68,34.22 93.76,34.3 93.76,34.8 93.84,34.88 94.19,34.88 94.32,35.01 94.32,35.39 94.45,35.52 97.62,35.52
AVDD18_SOC on IN2 (solid shape): 93.55,42.71 93.55,42.28 93.52,42.27 93.37,42.18 93.32,42.02 93.32,41.97 93.34,41.92 92.85,41.44 91.57,41.44 90.96,40.82 89.63,40.82 89.58,40.85 89.54,40.89 89.49,40.92 89.46,40.95 89.36,40.95 89.3,41.01 89.3,41.26 89.57,41.53 89.6,41.56 89.63,41.59 89.71,41.67 90.26,41.67 90.28,41.67 90.56,41.67 91.17,42.28 92.39,42.28 92.91,42.81 93.45,42.81
AVDD18_SOC on IN2 (solid shape): 93.83,47.66 90.43,44.25 90.43,44.01 90.43,43.84 90.37,43.75 90.35,43.65 90.36,43.59 90.38,43.53 90.38,43.38 90.33,43.33 90.21,43.28 90.17,43.16 90.17,43.11 90.17,43.08 89.7,42.62 89.38,42.62 89.33,42.68 89.33,42.91 89.37,42.96 89.43,42.96 89.46,42.99 89.48,43 89.55,43.03 89.59,43.1 89.6,43.11 89.85,43.36 89.85,43.98 90.45,44.58 90.64,44.77 90.65,44.77 90.72,44.81 90.76,44.88 90.76,44.89 90.8,44.93 90.8,45.04 93.63,47.87 93.83,47.87
AVDD18_SOC on IN3 (solid shape): outline of 199 points within 82.99,30.24 87.69,35.67
AVDD18_SOC on IN4 (solid shape): 87.51,32.14 87.51,31.76 87.36,31.61 86.92,31.61 86.78,31.75 86.09,31.75 85.9,31.94 85.9,32.33 86.01,32.44 87.21,32.44
AVDD18_SOC on IN4 (solid shape): 94.18,47.38 94.18,47.37 94.23,47.32 94.23,46.59 94.14,46.49 94.14,45.35 94.19,45.3 94.19,44.96 93.71,44.48 93.67,44.42 93.66,44.35 93.66,42.47 93.63,42.4 93.32,42.26 93.23,42.02 93.25,41.88 93.33,41.76 93.22,41.66 92.83,41.66 92.64,41.85 92.64,42.25 92.69,42.3 92.69,47.07 93.49,47.87 93.69,47.87
AVDD18_SOC on IN5 (solid shape): 87.66,31.98 87.66,30.41 87.4,30.14 84.81,30.14 84.44,30.51 84.44,30.63 86.25,32.44 87.2,32.44
AVDD18_SOC on IN5 (solid shape): outline of 139 points within 89.47,34.25 93.51,40.19
AVSS28_AUD on IN4 (solid shape): 30.59,25.76 30.59,25.3 30.49,25.2 29.17,25.2 29.04,25.33 29.04,25.76 29.17,25.89 30.46,25.89
DVDD_CORE on TOP (solid shape): 100.81,45.09 100.81,43.16 100.52,42.87 99.05,42.87 98.65,43.27 98.65,44.81 99.01,45.17 100.73,45.17
DVDD_CORE on TOP (solid shape): 94.84,33.18 95.57,33.18 95.77,32.98 95.77,32.04 95.73,32.01 94.73,32.01 94.73,31.92 94.72,31.92 94.62,31.81 93.61,31.81 93.49,31.92 93.49,32.88 93.69,33.07 93.69,33.11 93.86,33.27 94.75,33.27
DVDD_CORE on BOTTOM (solid shape): outline of 93 points within 83.93,36.31 101,44.51
DVDD_CORE on IN1 (solid shape): 86.74,40.46 86.74,36.32 86.65,36.23 86.24,36.23 86.13,36.33 86.13,40.41 86.24,40.51 86.68,40.51
DVDD_CORE on IN1 (solid shape): 88.38,37.4 88.38,36.31 88.33,36.25 87.84,36.25 87.69,36.41 87.69,37.6 87.78,37.7 88.09,37.7
DVDD_CORE on IN1 (solid shape): 93.92,32.89 93.99,32.86 94.06,32.85 94.14,32.86 94.21,32.89 94.47,32.89 94.95,32.41 94.95,31.88 94.89,31.82 93.69,31.82 93.57,31.94 93.57,32.8 93.66,32.89
DVDD_CORE on IN1 (solid shape): 85.2,40.75 85.2,40.56 85.17,40.51 85.16,40.45 85.17,40.39 85.2,40.34 85.2,37.84 84.67,37.84 84.33,38.17 84.15,38.17 83.83,37.85 82.97,37.85 82.91,37.91 82.91,38.81 82.98,38.88 83,38.88 83.01,38.89 83.77,38.89 84.11,38.55 84.37,38.55 84.48,38.66 84.48,40.76 84.59,40.86 85.08,40.86
DVDD_CORE on IN2 (solid shape): 86.73,40.34 86.73,38.66 86.64,38.56 86.24,38.56 86.13,38.66 86.13,39.91 86.62,40.4 86.67,40.4
DVDD_CORE on IN2 (solid shape): 94.95,32.21 94.95,31.88 94.85,31.78 93.68,31.78 93.59,31.88 93.59,32.22 93.58,32.22 93.58,32.57 93.86,32.85 94.32,32.85
DVDD_CORE on IN2 (solid shape): 85.18,40.81 85.18,39.15 85.03,39 84.62,39 84.44,39.18 84.44,40.7 84.45,40.75 84.44,40.81 84.54,40.91 85.08,40.91
DVDD_CORE on IN2 (solid shape): 101.14,45.05 101.32,44.88 101.32,43.26 101.04,42.99 101.01,42.95 100.99,42.9 100.97,42.88 100.43,42.88 100.29,43.02 100.29,43.02 100.25,43.06 99.67,43.06 99.59,43.14 98.86,43.14 98.74,43.25 98.74,43.9 99.25,44.41 99.29,44.47 99.31,44.54 99.31,44.7 99.35,44.78 99.43,44.8 99.48,44.79 99.53,44.79 99.72,44.84 99.85,44.99 99.9,45.02 99.94,45.05
DVDD_CORE on IN3 (solid shape): outline of 1082 points within 84.4,32.14 101.73,45.4
DVDD_CORE on IN4 (solid shape): 88.87,37.09 88.87,36.79 88.68,36.6 88.08,36.6 87.67,37.01 87.67,37.31 87.82,37.46 88.5,37.46
DVDD_CORE on IN4 (solid shape): 100.97,44.23 100.97,43.14 100.72,42.89 100.08,42.89 99.45,43.52 99.45,44.03 99.83,44.41 100.8,44.41
