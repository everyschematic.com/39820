# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSI5: length 34.4
  TOP w0.089: v2(145.96,16.92) 145.4,16.92 145.05,17.28 U6559.22
  IN2 w0.058: v2(145.96,16.92) 145.96,15.28 145.27,14.59 145.01,14.59 143.01,12.58 139.03,12.58 137.54,11.09 135.98,11.09 135.33,10.45 131.45,10.45 130.72,9.71 v2(130.72,9.69) 130.72,9.5 v3(130.54,9.32)
  IN4 w0.058: v3(130.54,9.32) v5(130.54,9.66)
  BOTTOM w0.089: v5(130.54,9.66) 130.64,9.76 CON7102.19 130.64,14.89 127.62,17.91 CON9105.19
KSI6: length 40.5
  TOP w0.089: v2(144.64,19.56) 144.38,19.82 142.73,19.82 142.5,19.59 U6559.26
  IN2 w0.058: v3(128,9.32) 128.19,9.32 v2(128.51,9.64) 128.6,9.73 129.65,9.73 129.91,9.99 130.29,9.99 130.5,10.2 130.62,10.2 131.32,10.9 135.19,10.9 136.5,12.21 137.36,12.21 138.24,13.09 142.84,13.09 144.76,15.01 145.09,15.01 145.44,15.35 145.44,17.77 144.31,18.9 144.31,19.23 v2(144.64,19.56)
  IN4 w0.058: v3(128,9.32) v5(128,9.66)
  BOTTOM w0.089: v5(128,9.66) 128.24,9.9 CON7102.22 128.24,12.59 128.13,12.71 127.66,12.71 127.22,13.15 127.22,16.78 125.22,18.79 CON9105.22
KSI7: length 41.8
  TOP w0.089: v2(144.71,19.97) 144.61,20.07 142.6,20.07 142.1,19.57 U6559.27
  IN2 w0.058: v2(144.71,19.97) 144.56,19.97 144.08,19.49 144.08,18.8 145.23,17.65 145.23,15.49 144.99,15.26 144.65,15.26 142.73,13.34 138.18,13.34 137.28,12.44 136.42,12.44 135.1,11.11 131.23,11.11 130.53,10.42 130.41,10.42 130.2,10.2 129.82,10.2 129.57,9.96 128.33,9.96 128.07,9.71 127.69,9.71 v2(127.67,9.69) 127.3,9.32 v3(127.24,9.32)
  IN4 w0.058: v3(127.24,9.32) v5(127.24,9.66)
  BOTTOM w0.089: v5(127.24,9.66) 127.44,9.86 CON7102.23 127.44,12.5 126.98,12.96 126.98,16.52 124.42,19.08 CON9105.23
KSO0: length 26.5
  TOP w0.089: U6559.11 142.5,11.84 v2(142.48,11.82)
  IN2 w0.058: v3(131.43,9.3) D2726.1 v2(131.45,9.71) 131.75,10.01 132.52,10.01 132.72,9.81 133.16,9.81 133.36,10.01 134.4,10.01 134.6,10.21 135.39,10.21 136.05,10.86 137.69,10.86 139.16,12.33 141.97,12.33 v2(142.48,11.82)
  IN4 w0.058: v5(131.43,9.66) v3(131.43,9.3)
  BOTTOM w0.089: CON9105.18 128.42,19.52 128.25,19.36 128.25,17.79 131.44,14.6 CON7102.18 131.44,9.67 v5(131.43,9.66)
KSO1: length 25.2
  TOP w0.089: U6559.13 144.29,13.68 144.38,13.59 144.38,12.66 v2(144.25,12.53)
  IN2 w0.058: v2(144.25,12.53) 144.25,12.33 142.88,10.95 140.6,10.95 140.04,10.39 136.18,10.39 135.5,9.71 135.19,9.71 v2(135.16,9.69) 134.8,9.32 v3(134.73,9.32)
  IN4 w0.058: v5(134.73,9.66) v3(134.73,9.32)
  BOTTOM w0.089: CON9105.14 131.62,19.25 134.64,16.23 CON7102.14 134.64,9.75 v5(134.73,9.66)
KSO2: length 118.6
  IN2 w0.058: v2(53.98,18.91) v3(53.65,18.91) ; v2(136.81,9.69) 136.81,9.63 v3(136.53,9.35) 136.1,8.92 132.06,8.92 131.68,8.54 131.68,8.08 131.38,7.78 125.79,7.78 125.41,7.4 124.11,7.4 123,6.29 91.14,6.29 88.16,9.27 85.7,9.27 84.69,10.28 81.68,10.28 80.56,9.85 79.61,9.44 75.46,5.3 75,5.3 72.93,3.22 68.7,3.22 68.17,2.69 65.53,2.69 60.13,8.1 60.13,8.26 59.85,8.54 59.31,8.54 v3(58.97,8.87)
  IN4 w0.058: v3(53.65,18.91) 53.11,19.45 52.57,19.45 51.77,18.64 v4(51.77,18.49) ; v4(58.15,9.53) 58.81,8.87 v3(58.97,8.87) ; v3(136.53,9.35) 136.38,9.51 v5(136.38,9.66)
  IN5 w0.076: v4(51.77,18.49) 51.84,18.42 51.84,17.7 51.06,16.93 51.06,15.27 50.53,14.74 50.53,13.85 51.44,12.93 51.44,11.94 52.51,10.88 54.39,10.88 55.38,9.89 57.79,9.89 v4(58.15,9.53)
  BOTTOM w0.089: CON9105.12 133.22,18.66 136.24,15.64 CON7102.12 136.24,9.8 v5(136.38,9.66)
KSO3: length 24.3
  TOP w0.089: v2(145.07,12.93) 145.07,13.42 144.4,14.08 U6559.14
  IN2 w0.058: v3(137.14,9.32) 137.3,9.48 v2(137.73,9.48) 137.95,9.71 138.74,9.71 138.97,9.94 140.47,9.94 141,10.47 143.16,10.47 145.07,12.38 v2(145.07,12.93)
  IN4 w0.058: v5(137.14,9.66) v3(137.14,9.32)
  BOTTOM w0.089: CON9105.11 134.02,18.37 137.04,15.35 CON7102.11 137.04,9.76 v5(137.14,9.66)
KSO4: length 28.3
  TOP w0.089: v2(145.12,14.26) 144.49,14.88 U6559.16
  IN2 w0.058: v3(133.84,9.32) 134.01,9.32 v2(134.37,9.69) 134.68,10 135.48,10 136.13,10.65 137.78,10.65 138.97,11.84 141.44,11.84 142.1,11.18 142.73,11.18 143.11,11.56 143.11,11.83 145.12,13.84 v2(145.12,14.26)
  IN4 w0.058: v5(133.84,9.66) v3(133.84,9.32)
  BOTTOM w0.089: CON9105.15 130.82,19.54 132.83,17.52 132.83,13.59 133.84,12.58 CON7102.15 133.84,9.66 v5(133.84,9.66)
KSO5: length 24.6
  TOP w0.089: D2716.1 140.26,9.48 v2(140.37,9.38) ; U6559.17 144.43,15.28 144.91,14.81 145.07,14.81 v2(145.78,14.1)
  IN2 w0.058: v3(139.68,9.32) 139.74,9.38 v2(140.37,9.38) 140.8,9.38 141.44,10.01 143.41,10.01 145.78,12.38 v2(145.78,14.1)
  IN4 w0.058: v5(139.68,9.66) v3(139.68,9.32)
  BOTTOM w0.089: v5(139.68,9.66) 139.44,9.9 CON7102.8 139.44,12.7 137.9,14.23 137.9,15.7 136.42,17.18 CON9105.8
KSO6: length 23.6
  TOP w0.089: U6559.15 144.44,14.48 145.4,13.52 v2(145.4,13.21)
  IN2 w0.058: v3(138.67,9.32) 138.91,9.32 v2(139.07,9.48) 139.3,9.71 140.75,9.71 141.28,10.24 143.32,10.24 145.4,12.33 v2(145.4,13.21)
  IN4 w0.058: v5(138.67,9.66) v3(138.67,9.32)
  BOTTOM w0.089: CON9105.9 135.62,17.4 137.52,15.5 137.52,13.72 138.64,12.61 CON7102.9 138.64,9.69 v5(138.67,9.66)
KSO7: length 26.1
  TOP w0.089: D2727.1 v2(129.29,9.3) ; v1(131.43,11.94) 131.53,11.84 134.58,11.84 135.14,11.28 138.51,11.28 139.3,12.07 U6559.3
  IN1 w0.076: v1(131.43,11.94) 130.82,11.33 130.72,11.33 129.68,10.29 129.68,9.68 v2(129.29,9.3)
  IN2 w0.058: v2(129.29,9.3) 129.27,9.32 v3(128.89,9.32)
  IN4 w0.058: v3(128.89,9.32) v5(128.89,9.66)
  BOTTOM w0.089: v5(128.89,9.66) 129.04,9.81 CON7102.21 129.04,15.48 126.02,18.5 CON9105.21
KSO8: length 23.7
  TOP w0.089: v1(137.33,11.74) 138.45,11.74 138.9,12.18 U6559.2
  IN1 w0.076: v1(137.33,11.74) 137.53,11.94 141.33,11.94 144.25,9.02 v2(144.25,8.99)
  IN2 w0.058: v3(144.25,9.32) v2(144.25,8.99)
  IN4 w0.058: v5(144.25,9.66) v3(144.25,9.32)
  BOTTOM w0.089: v5(144.25,9.66) 144.24,9.67 CON7102.2 144.24,12.72 143.87,13.09 143.37,13.09 143.01,13.44 143.01,17.89 141.22,19.68 CON9105.2
KSO9: length 17.7
  TOP w0.089: v2(143.37,8.99) 143.37,10.17 142.6,10.93 R91143.2 142.07,11.21 141.7,11.58 U6559.9
  IN2 w0.058: v3(143.37,9.32) v2(143.37,8.99)
  IN4 w0.058: v5(143.37,9.66) v3(143.37,9.32)
  BOTTOM w0.089: CON9105.3 140.42,19.92 141.71,18.62 141.71,13.98 142.48,13.21 142.73,13.21 143.44,12.51 CON7102.3 143.44,9.73 v5(143.37,9.66)
KSO10: length 16.7
  TOP w0.089: U6559.8 141.3,11.78 141.18,11.66 141.18,9.81 141.31,9.69 v2(141.59,9.69)
  IN2 w0.058: v2(141.59,9.69) v3(141.59,9.32)
  IN4 w0.058: v5(141.59,9.66) v3(141.59,9.32)
  BOTTOM w0.089: v5(141.59,9.66) 141.84,9.91 CON7102.5 141.84,12.58 141.21,13.21 141.21,17.95 139.62,19.54 139.02,19.54 138.82,19.74 CON9105.5
KSO11: length 17.4
  TOP w0.089: U6559.5 140.1,11.31 v1(140.21,11.2)
  IN1 w0.076: v1(140.21,11.2) 140.89,11.2 141.57,10.52 141.67,10.52 v2(142.5,9.69)
  IN2 w0.058: v2(142.5,9.69) v3(142.5,9.32)
  IN4 w0.058: v3(142.5,9.32) 142.48,9.35 v5(142.48,9.66)
  BOTTOM w0.089: v5(142.48,9.66) 142.64,9.82 CON7102.4 142.64,12.67 141.46,13.85 141.46,18.04 139.62,19.88 CON9105.4
KSO12: length 18.9
  TOP w0.089: U6559.10 142.1,11.56 142.43,11.23 143.32,11.23 145.14,9.4 v2(145.14,8.99)
  IN2 w0.058: v3(145.14,9.32) v2(145.14,8.99)
  IN4 w0.058: v5(145.14,9.66) v3(145.14,9.32)
  BOTTOM w0.089: v5(145.14,9.66) 145.04,9.76 CON7102.1 145.04,12.68 144.38,13.34 143.49,13.34 143.26,13.57 143.26,18.14 142.02,19.39 CON9105.1
KSO13: length 33
  TOP w0.089: U6559.7 140.9,11 140.17,10.27 138.29,10.27 138.03,10.52 134.68,10.52 134.27,10.93 130.62,10.93 v2(130.16,11.38)
  IN2 w0.058: v3(124.42,9.3) 124.72,9.61 v2(124.72,9.69) 124.72,10.13 125.43,10.84 127.66,10.84 128.01,11.19 129.06,11.19 129.41,11.53 130.01,11.53 v2(130.16,11.38)
  IN4 w0.058: v5(124.7,9.66) 124.7,9.61 124.42,9.33 v3(124.42,9.3)
  BOTTOM w0.089: v5(124.7,9.66) 125.04,10 CON7102.26 125.04,16.43 122.02,19.45 CON9105.26
KSO14: length 33.9
  TOP w0.089: U6559.6 140.5,11.64 140.57,11.56 140.57,11.06 140.02,10.51 139.16,10.51 138.64,11.03 134.98,11.03 134.48,11.54 131.26,11.54 v2(130.79,12.01)
  IN2 w0.058: v2(130.79,12.01) 130.67,12.12 129.4,12.12 128.89,11.61 127.84,11.61 127.51,11.28 124.87,11.28 123.5,9.92 123.5,9.89 v2(123.3,9.69) 123.2,9.59 v3(123.2,9.32)
  IN4 w0.058: v3(123.2,9.32) v5(123.2,9.66)
  BOTTOM w0.089: CON9105.28 120.42,19.4 123.44,16.38 CON7102.28 123.44,9.9 v5(123.2,9.66)
L0DN: length 4.6
  TOP w0.071: R192.2 68.92,44.49 68.87,44.53 67.94,44.53 67.43,45.04 66.56,45.04 65.52,44.01 65.52,43.9 65.59,43.82 U6578.F8
L0DP: length 4.7
  TOP w0.071: R193.2 68.77,44.76 68.03,44.76 67.53,45.26 66.46,45.26 65.3,44.1 65.3,43.87 U6578.E8
L1DN: length 3.5
  TOP w0.071: R191.2 68.68,41.4 68.38,41.4 68.09,41.7 68.09,42.1 67.07,43.11 66.55,43.11 U6578.H6
L1DP: length 3.5
  TOP w0.071: R194.2 68.68,41.62 68.48,41.62 68.31,41.79 68.31,42.2 67.17,43.34 66.55,43.34 U6578.H7
L2DN: length 5.9
  TOP w0.071: U6578.D8 64.75,43.82 64.68,43.9 64.68,44.41 66.25,45.98 68.55,45.98 68.6,46.04 68.85,46.04 68.92,45.96 R187.2
L2DP: length 5.9
  TOP w0.071: U6578.C8 64.46,44.5 66.16,46.2 68.46,46.2 68.51,46.26 68.74,46.26 R188.2
L3DN: length 4.2
  TOP w0.071: U6578.H4 66.55,42.31 66.66,42.31 67.34,41.63 67.34,40.69 68.14,39.89 68.66,39.89 R184.2
L3DP: length 4.1
  TOP w0.071: U6578.H5 66.55,42.54 66.75,42.54 67.57,41.72 67.57,40.78 68.23,40.11 68.69,40.11 R185.2
LDO3_VOUT: length 73.9
  TOP w0.254: R91305.2 v2(49.06,32.96) R91308.2 R91307.2 51.86,32.96 52.56,33.66 55.2,33.66 56.1,34.56 56.1,34.87 58.28,37.04 58.28,43.19 57.82,43.64 57.82,45.12 59.42,46.72 59.42,47.12 60.78,48.48 63.01,48.48 63.08,48.42 v2(67.29,48.42)
  IN2 w0.254: v2(67.29,48.42) 67.29,48.55 v3(67.47,48.72) ; v3(49,33.53) 49.03,33.53 49.06,33.51 v2(49.06,32.96)
  IN4 w0.254: v4(48.98,33.03) 48.98,33.51 v3(49,33.53) ; v3(67.47,48.72) 67.5,48.75 67.5,48.98 67.78,49.26 68.66,49.26 68.82,49.41 v5(69.38,49.41)
  IN5 w0.254: v5(60.82,20.72) 58.59,20.72 58.48,20.61 v5(57.69,20.61) ; v5(50.33,33.92) 50.33,33.8 49.87,33.33 49.28,33.33 v4(48.98,33.03) 48.98,32.77 48.7,32.49 48.37,32.49 48.17,32.29 48.17,28.96 50.86,26.27 50.86,23.84 v5(50.86,23.84)
  BOTTOM w0.229: U6571.11 51.58,31.91 51.42,32.08 PC136.1 51.17,32.08 50.86,32.39 50.86,33.39 v5(50.33,33.92)
  BOTTOM w0.254: R91330.1 60.54,23.23 60.54,21 v5(60.82,20.72) ; v5(69.38,49.41) 70.09,49.41 70.47,49.03 72.37,49.03 73.64,47.76 R91318.1 ; v5(50.86,23.84) 51.48,23.84 51.88,24.24 55.35,24.24 57.69,21.9 v5(57.69,20.61)
LDO5_VOUT: length 28.4
  TOP w0.254: R91314.2 60.69,3.56 61.08,3.17 61.08,2.41 61.33,2.16 62.97,2.16 v1(64.63,3.82) ; v2(66.28,17.66) 66.28,14.36 64.5,12.58 v1(64.5,8.77) 64.5,7.75 65.01,7.25 65.01,5.21 v1(65.64,4.58)
  IN1 w0.254: v1(64.63,3.82) 64.88,3.82 v1(65.64,4.58) ; v1(64.5,8.77) 64.47,8.8 v1(61.7,8.8)
  IN2 w0.254: v3(66.53,17.91) v2(66.28,17.66)
  IN4 w0.254: v3(66.53,17.91) 66.72,18.1 v5(66.72,18.23)
  BOTTOM w0.229: U6570.12 v5(66.72,18.23) 66.86,18.37 PC131.1
LED_BLUE_ISINK: length 2.3
  TOP w0.089: R91163.2 136.46,16.08 U6559.42
LED_GREEN_ISINK: length 2.1
  TOP w0.089: R91162.2 135.85,16.48 U6559.41
LED_ORANGE_ISINK: length 2.2
  TOP w0.089: R91161.2 136.14,16.77 136.89,16.77 137,16.88 U6559.40
LID_ACCEL_INT_L_R: length 38.9
  TOP w0.089: Q786.1 145.74,38.35 146.01,38.08 v2(146.29,38.08)
  IN2 w0.058: v3(145.02,40.01) 145.62,40.01 146.19,39.44 146.19,38.18 v2(146.29,38.08)
  IN3 w0.102: v3(145.02,40.01) 144.69,40.01 143.2,41.5 141.09,41.5 138.39,44.2 136.36,44.2 135.54,45.01 135.54,47.75 135.45,47.84 135.45,53.33 134.58,54.21 134.58,56.31 133.73,57.16 132.85,57.16 131.85,58.15 129.61,58.15 129.17,58.59 129.17,59.11 v3(129.12,59.16)
  IN4 w0.058: v5(127.9,63.3) 128.08,63.12 128.08,59.89 128.81,59.16 v3(129.12,59.16)
LID_ACCEL_INT_ODL: length 1
  TOP w0.089: TP9183.1 142.97,37.85 Q786.3
LID_OPEN: length 200.4
  TOP w0.089: R91174.2 v2(124.85,53.96) 124.85,54.17 124.34,54.68 124.34,55.24 123.83,55.75 R91279.1 123.11,55.75 123.1,55.73 R91302.1 ; D2739.1 40.56,38.17 40.39,38.35 40.39,39.73 39.11,41.01 38.5,41.01 v2(38.36,41.15) 38.36,44.18 39.02,44.83 39.02,44.92 39.99,45.89 42.29,45.89 42.53,46.13 46.57,46.13 47.07,46.64 54.11,46.64 54.29,46.82 55.15,46.82 55.33,46.64 56.21,46.64 58.16,48.58 59.1,48.58 60.25,49.74 63.66,49.74 63.74,49.66 66.43,49.66 v2(66.66,49.89)
  IN1 w0.076: v2(133.22,39.13) 132.34,40.01 132.34,48.37 131.33,49.38 131.33,51.28 128.96,53.64 128.96,53.97 128.63,54.3 125.17,54.3 124.85,53.98 v2(124.85,53.96) ; v1(127.24,66.71) 127.24,65.46 125.74,63.96 125.74,60.13 125.46,59.85 125.46,59.24 v2(123.33,57.11)
  IN2 w0.058: v2(133.22,39.13) 133.79,38.56 137.07,38.56 140.32,35.31 140.32,34.8 140.67,34.45 v3(140.67,30.23) ; v3(36.64,33.58) 36.64,34.27 36.91,34.55 36.91,35.31 37.33,35.73 37.85,35.73 38.13,36.02 38.13,37.62 37.8,37.95 37.8,40.59 v2(38.36,41.15) ; v2(123.33,57.11) 123.14,56.92 123.14,56.05 123.6,55.59 123.6,54.84 124.09,54.36 v3(124.85,54.36) v2(124.85,53.96) ; v2(66.66,49.89) 66.66,49.96 66.72,50.02 66.73,50.02 66.86,50.15 v3(66.86,50.17)
  IN3 w0.102: v3(124.85,54.36) 124.47,54.74 124.25,54.74 123.05,55.95 123.05,57.7 122.28,58.46 121.08,58.46 119.88,59.67 119.88,60.88 116.06,64.7 76.99,64.7 72.54,60.26 71.42,60.26 69.68,58.52 69.68,54.03 68.44,52.79 68.44,51.31 67.29,50.17 v3(66.86,50.17)
  IN4 w0.058: v5(36.61,13.01) 37.3,13.69 37.3,14.87 36.64,15.52 35.89,15.52 35.3,16.11 35.3,23.42 36.57,24.69 36.57,28.72 37.07,29.22 37.07,31.86 36.57,32.35 36.57,33.52 v3(36.64,33.58) ; v5(141.24,30.23) v3(140.67,30.23)
  BOTTOM w0.089: v5(36.61,13.01) 36.84,13.01 37.45,12.4 R91181.2
MDSI_TE: length 3.2
  TOP w0.075: 91.12,33.81 90.89,33.81 U1001.AG26
  TOP w0.089: TP9141.1 90.66,32.01 90.98,32.33 91.13,32.33 91.4,32.59 91.4,33.53 91.12,33.81
MECH_PWR_BTN_ODL: length 22.8
  TOP w0.089: v2(125.97,9.31) 125.99,9.31 126.14,9.46 R91121.2 D2731.1
  IN2 w0.058: v2(132.85,10.14) 132.75,10.23 131.54,10.23 131.15,9.84 131.15,9.61 130.95,9.4 130.95,9.12 130.72,8.9 126.15,8.9 126.08,8.82 v3(125.82,8.82) 125.82,9.16 v2(125.97,9.31)
  IN4 w0.058: v3(125.82,8.82) 125.59,9.06 v5(125.59,9.66)
  BOTTOM w0.089: CON9105.25 122.82,19.41 125.59,16.64 125.59,12.96 125.84,12.71 CON7102.25 125.84,9.91 v5(125.59,9.66)
MIC_P: length 1.9
  TOP w0.254: R90781.2 9.1,24.81 9.29,24.81 9.56,25.08 10.56,25.08 U6541.B4
MIC_PRESENT_L: length 97.1
  TOP w0.089: v2(17.45,27.02) 17.17,27.02 16.72,26.57 16.72,25.53 15.17,23.98 13.32,23.98 13.11,24.19 12.25,24.19 U6541.A1
  IN1 w0.06: v7(82.24,41.16) 82.43,40.96 82.43,40.64 82.35,40.56 81.15,40.56 81.03,40.68 80.91,40.68
  IN1 w0.076: 80.91,40.68 80.56,41.03 80.33,41.03 79.49,41.87 78.24,41.87 77.25,42.86 75.51,42.86 72.4,45.97 72.4,50.63 72.5,50.73 v2(72.5,50.88)
  IN2 w0.058: v2(17.45,27.02) 17.45,27.3 17.71,27.56 17.71,28.1 17.89,28.28 17.89,28.71 18.58,29.41 18.58,30.82 18.88,31.12 25.26,31.12 25.41,31.27 26.2,31.27 26.53,30.94 28.77,30.94 31.31,33.48 31.53,33.48 31.73,33.69 31.73,34.91 32.27,35.44 32.27,40.36 34.75,42.84 35.94,42.84 37.46,44.36 38.4,44.36 38.98,44.95 39.43,44.95 40.45,45.96 42.41,45.96 42.72,45.66 45.18,45.66 45.28,45.75 52.9,45.75 53.28,45.37 55.27,45.37 56.97,47.06 58.07,47.06 58.2,47.19 59.38,47.19 60.72,48.52 62.75,48.52 63.5,49.27 64.37,49.27 66.36,51.26 68.5,51.26 69.1,50.65 72.09,50.65 72.32,50.88 v2(72.5,50.88)
MIPIBRDG_INT_ODL: length 35.9
  TOP w0.089: v1(73.74,41.76) 73.67,41.76 73.52,41.92 73.44,41.92 72.98,42.38 72.98,46.68 71.89,47.76 68.97,47.76 68.65,48.08 64.65,48.08 64.4,47.83 64.4,46.92 64.2,46.72 R91238.2 62.57,45.3 62.57,44.25 62.75,44.08 63.81,44.08 U6578.B8
  IN1 w0.076: v2(77.3,31.17) 77.3,31.43 76.54,32.19 76.54,33.84 75.98,34.4 74.65,34.4 74.06,35 74.06,36.52 73.69,36.89 73.69,41.74 73.72,41.76 v1(73.74,41.76)
  IN2 w0.058: v2(77.3,31.17) 77.3,31.13 77.36,31.07 77.65,31.07 78.07,30.65 78.07,29.85 v2(78.42,29.5)
MIPIBRDG_PWRDN_L_1V8: length 62.4
  TOP w0.06: U1001.AH27 91.25,32.94 91.25,32.65 91.12,32.52 90.74,32.52 90.67,32.45
  TOP w0.089: 90.67,32.45 90.13,31.91 90.13,31.3 89.64,30.81 TP9181.1 89.64,30 90.08,29.57 90.38,29.57 90.64,29.32 90.64,27.54 90.99,27.18 91.65,27.18 91.8,27.03 91.8,25.79 91.65,25.63 90.43,25.63 90.28,25.48 90.28,24.77 89.87,24.36 87.94,24.36 87.91,24.4 v2(87.89,24.4) ; v1(60.33,38.72) 60.36,38.69 60.79,38.69 60.91,38.57 R91254.2 60.91,37.98 60.22,37.28 60.22,34.69 59.47,33.94 59.47,32.92 v2(59.44,32.9)
  IN1 w0.076: v1(64.86,41.42) 64.86,41.08 63.92,40.14 63.92,40.07 63.41,39.55 61.25,39.55 60.41,38.72 v1(60.33,38.72)
  IN2 w0.058: v2(87.89,24.4) 87.89,24.29 87.08,23.47 85.4,23.47 85.11,23.76 83.95,23.76 83.49,23.3 79.51,23.3 76.27,26.54 75.72,26.54 72.85,29.41 72.85,30.6 71.8,31.65 69.61,31.65 69.02,32.23 68.24,32.23 67.66,31.65 67.01,31.65 66.38,31.02 63.7,31.02 62.18,32.54 59.8,32.54 v2(59.44,32.9)
MIPIBRDG_RST_L_1V8: length 46.6
  TOP w0.089: TP9180.1 76.01,33.46 v2(75.93,33.53) ; R91253.2 61.2,44.33 62.09,43.44 v1(62.09,43.41)
  IN1 w0.06: v7(82.24,33.96) 82.12,33.85 v2(82.12,33.53)
  IN1 w0.076: v1(64.06,43.42) 63.94,43.54 62.21,43.54 v1(62.09,43.41) 61.6,43.9 59.83,43.9 59.42,43.49 59.42,42.98 58.02,41.59 57.34,41.59 56.7,40.95 56.7,39.58 v2(58.89,37.39)
  IN2 w0.058: v2(82.12,33.53) 82.02,33.64 80.42,33.64 80.2,33.41 76.06,33.41 v2(75.93,33.53) 75.93,35.39 74.06,37.26 72.07,37.26 71.32,38 68.06,38 67.6,38.47 66.59,38.47 65.98,37.86 65.98,35.4 65.76,35.18 60.97,35.18 58.89,37.27 v2(58.89,37.39)
MSDC0_CLK: length 31.6
  TOP w0.089: U6522.7 114.9,53.36 114.68,53.14 113.34,53.14 v2(113.09,53.4)
  IN1 w0.06: 90.43,42.96 90.04,42.96 v7(89.83,42.76)
  IN1 w0.076: 90.43,42.96 90.74,42.96 90.75,42.95 91.28,42.95 91.83,43.5 92.32,43.5 93.46,44.64 94.45,44.64 95.72,45.91 v2(96.07,45.91)
  IN2 w0.058: v2(113.09,53.4) 112.97,53.52 110.76,53.52 110.42,53.17 103.88,53.17 102.5,51.79 99.56,51.79 98.48,50.71 98.48,49.81 98.13,49.46 98.13,48.53 96.96,47.36 96.96,46.66 96.43,46.13 96.32,46.13 96.1,45.91 v2(96.07,45.91)
MSDC0_CLK_EMMC: length 11.6
  TOP w0.089: v2(115.19,53.08) 115.3,53.19 U6522.8
  IN2 w0.058: v2(106.89,58.86) 106.97,58.78 108.03,58.78 108.09,58.83 108.52,58.83 109.3,58.05 110.55,58.05 114,54.6 114,54.27 v2(115.19,53.08)
MSDC0_CMD: length 29.4
  TOP w0.089: U6522.2 113.57,55.06 113.29,54.78 v2(113.29,54.59)
  IN1 w0.076: v7(91.03,43.16) 91.11,43.16 91.68,43.73 92.19,43.73 93.33,44.87 94.35,44.87 95.77,46.29 96.04,46.29 v2(96.07,46.32)
  IN2 w0.058: v2(96.07,46.32) 96.07,46.59 96.29,46.82 96.29,47.19 97.78,48.68 97.78,49.79 98.1,50.11 98.1,50.83 99.42,52.14 102.36,52.14 103.74,53.52 110.27,53.52 110.64,53.89 112.4,53.89 113.1,54.59 v2(113.29,54.59)
MSDC0_CMD_EMMC: length 8.7
  TOP w0.089: R91008.1 113.5,55.42 113.54,55.46 U6522.1
  IN2 w0.058: v2(106.89,58.36) 107.47,58.36 108.08,57.75 109.22,57.75 109.28,57.69 109.28,57.54 109.38,57.44 109.58,57.44 109.66,57.51 109.66,57.61 109.8,57.75 110.5,57.75 112.76,55.49 v2(112.76,55.4)
MSDC0_DAT0: length 29.1
  TOP w0.089: v2(113.67,53.68) U6522.5
  IN1 w0.076: v7(90.64,43.56) 91,43.56 91.4,43.96 92.1,43.96 93.24,45.1 94.26,45.1 95.8,46.64 96.5,46.64 v2(96.6,46.74)
  IN2 w0.058: v2(113.67,53.68) 113.64,53.72 110.71,53.72 110.34,53.35 103.81,53.35 102.43,51.97 99.49,51.97 98.28,50.76 98.28,49.92 97.95,49.59 97.95,48.61 96.6,47.26 v2(96.6,46.74)
MSDC0_DAT0_EMMC: length 14.1
  TOP w0.089: U6522.4 113.14,54.26 113.05,54.35 R91009.1 112.27,54.35 v2(111.99,54.62)
  IN2 w0.058: v8(101.39,57.36) 101.71,57.67 102.02,57.67 102.38,57.31 103.82,57.31 103.95,57.19 106.12,57.19 106.78,56.53 109.96,56.53 111.71,54.78 111.84,54.78 v2(111.99,54.62)
MSDC0_DAT1: length 49.8
  TOP w0.06: 91.4,44.08 91.25,43.93 91.25,43.78 U1001.B27
  TOP w0.089: 91.4,44.08 92.14,44.81 92.14,45.17 93.55,46.59 94.93,46.59 v2(95.16,46.82)
  IN2 w0.058: v2(101.39,57.86) 101.28,57.97 101.07,57.97 100.99,57.88 100.99,57.67 101.1,57.56 101.1,57.38 100.99,57.27 100.99,57.14 101.07,57.05 101.66,57.05 101.71,57 101.71,56.9 101.66,56.85 101.24,56.85 101.18,56.79 101.18,56.71 101.24,56.65 101.61,56.65 102.35,55.91 102.35,55.32 102.68,54.99 103.15,54.99 103.48,55.31 103.48,55.63 103.74,55.9 103.74,56.75 103.79,56.8 103.97,56.8 104.05,56.72 104.05,56.24 104.14,56.15 109.09,56.15 109.16,56.07 109.16,54.75 109.1,54.69 109.03,54.69 108.96,54.75 108.96,55.92 108.91,55.97 108.84,55.97 108.79,55.92 108.79,54.34 108.74,54.29 108.67,54.29 108.61,54.34 108.61,55.92 108.56,55.97 108.49,55.97 108.44,55.92 108.44,54.07 108.39,54.02 108.31,54.02 108.26,54.07 108.26,55.92 108.21,55.97 108.14,55.97 108.09,55.92 108.09,54.07 108.04,54.02 103.44,54.02 102.06,52.64 98.75,52.64 98.15,52.04 98.15,51.69 97.57,51.11 97.57,50.46 97.28,50.17 97.28,48.89 95.79,47.4 95.79,47.02 95.59,46.82 v2(95.16,46.82)
MSDC0_DAT2: length 51.1
  TOP w0.06: U1001.A26 90.64,44 90.84,44.21 91.03,44.21 91.1,44.28
  TOP w0.089: U18.A5 v8(101.39,58.34) ; v2(95.49,47.15) 94.95,47.15 94.68,46.88 93.46,46.88 91.87,45.28 91.87,44.92 91.22,44.28 91.1,44.28
  IN2 w0.058: v2(95.49,47.15) 95.49,47.34 97.11,48.96 97.11,50.35 97.39,50.64 97.39,51.19 97.93,51.72 97.93,52.06 98.68,52.82 101.99,52.82 103.37,54.19 107.78,54.19 107.91,54.33 107.91,55.92 107.86,55.97 107.77,55.97 107.72,55.92 107.72,54.42 107.67,54.37 107.6,54.37 107.55,54.42 107.55,55.92 107.5,55.97 107.42,55.97 107.37,55.92 107.37,54.42 107.32,54.37 107.25,54.37 107.2,54.42 107.2,55.92 107.15,55.97 107.05,55.97 107,55.92 107,54.42 106.94,54.37 106.87,54.37 106.82,54.42 106.82,55.92 106.77,55.97 106.7,55.97 106.65,55.92 106.65,54.42 106.59,54.37 106.52,54.37 106.47,54.42 106.47,55.92 106.42,55.97 106.35,55.97 106.3,55.92 106.3,54.47 106.24,54.41 106.18,54.41 106.12,54.47 106.12,55.92 106.08,55.96 104.06,55.96 103.65,55.56 103.65,55.24 103.22,54.81 102.61,54.81 102.17,55.25 102.17,55.84 101.54,56.47 101.16,56.47 100.81,56.82 100.81,58.02 100.96,58.16 101.22,58.16 v8(101.39,58.34)
MSDC0_DAT3: length 49.9
  IN1 w0.076: v2(99.96,57.79) 99.96,57.16 100.43,56.68 101.67,56.68 101.82,56.83 v1(101.82,56.86)
  IN2 w0.058: v8(89.83,42.36) 89.83,42.45 89.94,42.56 90.41,42.56 91.3,43.45 91.3,44.15 96.39,49.23 96.39,51.53 v2(96.66,51.8) 96.66,51.9 97.26,52.5 97.26,53.11 97.32,53.17 97.87,53.17 97.93,53.23 97.93,53.3 97.88,53.34 97.31,53.34 97.26,53.4 97.26,53.47 97.3,53.52 98.99,53.52 99.05,53.57 99.05,53.63 98.99,53.69 97.32,53.69 97.26,53.75 97.26,53.83 97.3,53.87 99.02,53.87 99.05,53.9 99.05,54.01 99.02,54.04 97.32,54.04 97.26,54.1 97.26,54.18 97.3,54.22 99.01,54.22 99.05,54.26 99.05,54.36 99.02,54.39 97.3,54.39 97.26,54.44 97.26,54.51 97.31,54.57 99.01,54.57 99.05,54.62 99.05,54.69 99,54.74 97.31,54.74 97.26,54.79 97.26,54.87 97.31,54.92 98.61,54.92 98.66,54.97 98.66,55.05 98.61,55.1 97.31,55.1 97.26,55.15 97.26,55.23 97.3,55.27 98.6,55.27 98.66,55.33 98.66,55.4 98.61,55.45 97.32,55.45 97.26,55.51 97.26,55.56 97.32,55.62 98.6,55.62 98.66,55.68 98.66,55.75 98.61,55.8 97.32,55.8 97.26,55.86 97.26,55.91 97.32,55.97 98.62,55.97 98.66,56.01 98.66,56.1 98.61,56.15 97.32,56.15 97.26,56.21 97.26,56.27 97.31,56.32 98.56,56.32 98.64,56.39 98.64,56.57 98.74,56.67 99.83,56.67 99.96,56.8 v2(99.96,57.79)
MSDC0_DAT4: length 49.9
  TOP w0.06: U1001.C26 90.86,42.94 91.13,42.94 91.42,43.23 91.42,43.62
  TOP w0.089: v2(94.09,45.7) 93.84,45.95 93.3,45.95 92.4,45.06 92.4,44.7 91.42,43.72 91.42,43.62
  IN2 w0.058: v2(94.09,45.7) 94.09,45.94 94.64,46.49 95.51,46.49 95.97,46.95 95.97,47.32 97.46,48.81 97.46,50.02 97.76,50.32 97.76,51.02 98.46,51.72 98.46,52.1 98.83,52.47 102.14,52.47 103.51,53.84 108.57,53.84 109.34,54.62 109.34,56.1 109.39,56.15 109.47,56.15 109.52,56.11 109.52,55.08 109.57,55.03 109.64,55.03 109.69,55.08 109.69,56.1 109.74,56.15 109.83,56.15 109.87,56.11 109.87,55.8 109.92,55.74 109.99,55.74 110.04,55.79 110.04,56.19 109.91,56.32 106.63,56.32 106.49,56.47 106.31,56.47 106.16,56.32 106.06,56.32 106.01,56.38 106.01,56.98 105.96,57.03 105.89,57.03 105.84,56.98 105.84,56.38 105.79,56.32 105.71,56.32 105.66,56.38 105.66,56.98 105.61,57.03 105.54,57.03 105.49,56.98 105.49,56.38 105.44,56.32 105.36,56.32 105.31,56.38 105.31,56.98 105.26,57.03 105.19,57.03 105.14,56.98 105.14,56.38 105.08,56.32 105.01,56.32 104.96,56.38 104.96,56.98 104.91,57.03 104.84,57.03 104.79,56.98 104.79,56.38 104.73,56.32 104.66,56.32 104.61,56.38 104.61,56.98 104.56,57.03 104.49,57.03 104.44,56.98 104.44,56.38 104.38,56.32 104.31,56.32 104.26,56.38 104.26,56.98 104.21,57.03 103.74,57.03 103.56,56.85 103.56,55.97 103.3,55.7 103.3,55.39 103.08,55.16 102.76,55.16 102.52,55.4 102.52,55.99 101.89,56.62 101.89,56.95 102.07,57.12 102.07,57.28 101.99,57.36 v2(101.89,57.36)
MSDC0_DAT5: length 50.8
  TOP w0.089: v8(90.34,43.16) U1001.C25
  IN1 w0.076: v1(101.89,57.86) 102.22,58.19 102.22,59 102.07,59.16 100.49,59.16 v2(100.39,59.06)
  IN2 w0.058: v8(90.34,43.16) 90.6,43.16 90.97,43.53 90.97,44.31 96.04,49.38 96.04,52.12 v2(96.22,52.3) 96.22,52.38 96.9,53.06 96.9,59.9 96.96,59.95 97.03,59.95 97.08,59.9 97.08,58.61 97.13,58.56 97.2,58.56 97.25,58.61 97.25,59.9 97.31,59.95 97.38,59.95 97.43,59.9 97.43,58.61 97.48,58.56 97.55,58.56 97.61,58.61 97.61,59.9 97.66,59.95 97.73,59.95 97.78,59.9 97.78,58.61 97.83,58.56 97.9,58.56 97.96,58.61 97.96,59.9 98.01,59.95 98.08,59.95 98.13,59.9 98.13,58.61 98.18,58.56 98.26,58.56 98.31,58.61 98.31,59.9 98.36,59.95 98.43,59.95 98.48,59.9 98.48,58.61 98.53,58.56 98.61,58.56 98.66,58.61 98.66,59.9 98.71,59.95 98.78,59.95 98.83,59.9 98.83,58.61 98.88,58.56 98.96,58.56 99.01,58.61 99.01,59.9 99.06,59.95 99.13,59.95 99.18,59.9 99.18,58.61 99.23,58.56 99.31,58.56 99.36,58.61 99.36,59.9 99.41,59.95 99.48,59.95 99.53,59.9 99.53,58.69 99.58,58.64 99.66,58.64 99.71,58.69 99.71,59.87 99.76,59.93 99.83,59.93 99.88,59.87 99.88,58.71 99.95,58.64 100.03,58.64 100.08,58.69 100.08,59.83 100.14,59.89 100.31,59.89 100.39,59.81 v2(100.39,59.06)
MSDC0_DAT6: length 49.8
  TOP w0.089: U1001.G23 89.07,41.93 v8(89.07,41.97)
  IN2 w0.058: v2(101.89,58.36) 101.75,58.36 101.68,58.43 101.68,58.66 101.52,58.81 101.34,58.81 100.64,58.11 100.64,56.75 101.09,56.3 101.47,56.3 102,55.77 102,55.18 102.64,54.54 102.75,54.54 102.85,54.64 103.01,54.64 103.1,54.55 103.19,54.55 103.28,54.64 103.39,54.64 103.48,54.55 103.57,54.55 103.63,54.6 103.63,54.97 103.68,55.02 103.74,55.02 103.8,54.96 103.8,54.59 103.84,54.55 103.93,54.55 103.98,54.6 103.98,55.63 104.02,55.68 104.11,55.68 104.15,55.64 104.15,54.59 104.2,54.55 104.28,54.55 104.33,54.6 104.33,55.73 104.38,55.79 104.45,55.79 104.5,55.74 104.5,54.6 104.55,54.55 104.63,54.55 104.68,54.6 104.68,55.73 104.73,55.79 104.8,55.79 104.85,55.73 104.85,54.6 104.9,54.55 104.98,54.55 105.03,54.6 105.03,55.73 105.08,55.79 105.18,55.79 105.23,55.73 105.23,54.6 105.28,54.55 105.35,54.55 105.4,54.6 105.4,55.73 105.46,55.79 105.53,55.79 105.58,55.73 105.58,54.6 105.63,54.55 105.7,54.55 105.76,54.6 105.76,55.73 105.81,55.78 105.89,55.78 105.94,55.73 105.94,54.43 105.88,54.37 103.3,54.37 101.92,52.99 98.55,52.99 97.6,52.04 97.6,51.69 97.06,51.16 v2(97.06,50.76) 96.91,50.61 96.91,49.01 93.77,45.87 93.77,45.48 93.57,45.28 92.93,45.28 91.63,43.97 91.63,42.91 91.5,42.78 91.05,42.78 90.43,42.16 89.73,42.16 89.67,42.22
  IN2 w0.06: v8(89.07,41.97) 89.11,41.97 89.41,42.27 89.62,42.27 89.67,42.22
MSDC0_DAT7: length 49.8
  TOP w0.06: U1001.D26 90.66,42.74 91.17,42.74 91.7,43.27 91.7,43.44
  TOP w0.089: v2(93.45,45.6) 93.45,45.38 91.7,43.63 91.7,43.44
  IN2 w0.058: v2(93.45,45.6) 93.45,45.8 96.74,49.09 96.74,51.14 97.27,51.67 97.27,51.96 98.48,53.17 101.85,53.17 101.89,53.21 101.89,53.3 101.85,53.34 99.45,53.34 99.4,53.39 99.4,53.47 99.45,53.52 102.19,53.52 102.25,53.57 102.25,53.64 102.19,53.69 99.45,53.69 99.4,53.74 99.4,53.82 99.45,53.87 102.55,53.87 102.6,53.92 102.6,53.99 102.55,54.04 99.45,54.04 99.4,54.1 99.4,54.17 99.45,54.22 102.53,54.22 102.57,54.26 102.57,54.35 102.52,54.39 99.45,54.39 99.4,54.45 99.4,54.52 99.45,54.57 102.14,54.57 102.18,54.62 102.18,54.69 102.13,54.74 101.23,54.74 101.18,54.79 101.18,54.87 101.23,54.92 101.76,54.92 101.82,54.98 101.82,55.7 101.4,56.12 101.02,56.12 100.46,56.68 100.46,58.18 101.27,58.99 101.76,58.99 v8(101.89,58.85)
MSDC0_DSL: length 50.2
  TOP w0.089: U18.H5 104.9,57.97 v2(104.85,57.93)
  IN2 w0.058: v2(104.85,57.93) 104.8,57.87 104.15,57.87 103.9,58.12 102.63,58.12 102.19,58.57 102.19,59.09 102.11,59.17 101.2,59.17 100.29,58.25 100.29,56.6 100.19,56.5 98.89,56.5 98.83,56.45 98.83,56.37 98.89,56.32 100.52,56.32 100.57,56.27 100.57,56.2 100.52,56.15 98.89,56.15 98.83,56.1 98.83,56.02 98.89,55.97 100.93,55.97 100.97,55.93 100.97,55.84 100.93,55.8 98.89,55.8 98.83,55.75 98.83,55.67 98.89,55.62 101.59,55.62 101.64,55.58 101.64,55.49 101.59,55.45 98.89,55.45 98.83,55.39 98.83,55.32 98.89,55.27 101.58,55.27 101.65,55.21 101.65,55.15 101.59,55.1 98.89,55.1 98.83,55.04 98.83,54.97 98.89,54.92 100.95,54.92 101,54.87 101,54.8 100.95,54.74 99.35,54.74 99.23,54.62 99.23,53.38 99.19,53.34 98.4,53.34 97.9,52.84 97.71,52.84 v2(97.58,52.71) 97.58,52.52 97.05,51.99 97.05,51.75 96.56,51.26 96.56,49.16 91.45,44.04 91.45,43.41 90.4,42.36 v8(90.24,42.36)
MSDC0_RSTB: length 53.4
  IN2 w0.058: v8(90.24,42.76) 90.4,42.76 91.13,43.49 91.13,44.22 96.21,49.3 96.21,51.84 96.86,52.48 v2(96.86,52.56) 96.86,52.63 97.08,52.86 97.08,58.23 97.16,58.31 97.23,58.31 97.28,58.26 97.28,56.55 97.33,56.5 97.41,56.5 97.46,56.55 97.46,58.26 97.51,58.31 97.58,58.31 97.63,58.26 97.63,56.55 97.69,56.5 97.76,56.5 97.81,56.55 97.81,58.28 97.86,58.33 97.93,58.33 97.98,58.28 97.98,56.55 98.04,56.5 98.11,56.5 98.16,56.55 98.16,58.28 98.21,58.33 98.28,58.33 98.33,58.28 98.33,56.69 98.39,56.64 98.46,56.64 98.51,56.69 98.51,58.33 98.56,58.38 98.63,58.38 98.69,58.33 98.69,56.9 98.74,56.85 98.81,56.85 98.86,56.9 98.86,58.33 98.91,58.38 98.98,58.38 99.04,58.33 99.04,56.9 99.09,56.85 99.16,56.85 99.21,56.9 99.21,58.33 99.26,58.38 99.34,58.38 99.39,58.33 99.39,56.9 99.44,56.85 99.51,56.85 99.56,56.9 99.56,58.33 99.61,58.38 99.69,58.38 99.74,58.33 99.74,58.15 99.79,58.1 99.86,58.1 99.91,58.15 99.91,58.41 99.96,58.46 100.25,58.46 101.13,59.34 102.18,59.34 102.36,59.16 102.36,58.64 102.7,58.3 103.97,58.3 104.22,58.05 104.53,58.05 104.72,58.24 105.02,58.24 105.06,58.29 105.06,58.66 105.13,58.73 105.47,58.73 105.57,58.63 105.57,58.13 105.8,57.89 105.9,57.89 106,57.99 106,58.25 v2(105.89,58.36)
MSDC1_CLK: length 114.5
  TOP w0.089: v2(95.92,24.99) 95.92,25.05 95.28,25.69 93.75,25.69 93.27,26.17 R90696.2 ; R90504.2 137.68,60.69 v2(137.52,60.84)
  IN2 w0.058: v2(95.92,24.99) 95.94,24.96 95.94,23.13 97.63,21.44 103.51,21.44 105.32,23.25 105.32,23.58 106.72,24.98 107.94,24.98 108.04,25.08 111.43,25.08 113.06,23.45 113.47,23.45 113.67,23.25 113.67,22.79 114.05,22.41 114.06,22.41 115.12,21.35 115.12,17.72 115.25,17.59 115.25,16.62 114.87,16.24 114.87,14.61 115.72,13.77 117.67,13.77 119.88,15.97 119.88,16.89 120.15,17.15 123.27,17.15 124.15,18.03 128.29,18.03 128.6,18.35 130.87,18.35 131.01,18.2 132.58,18.2 135.2,20.82 140.17,20.82 142.35,22.99 142.35,26.03 143.51,27.19 143.51,28.11 142.44,29.18 142.44,38.1 141.67,38.86 141.67,41.13 137.62,45.18 137.02,45.18 134.38,47.82 134.38,57.07 133.97,57.49 133.97,58.25 134.93,59.21 134.93,60.51 135.19,60.76 137.45,60.76 v2(137.52,60.84)
MSDC1_CMD: length 119.3
  TOP w0.089: R90505.2 136.97,60.6 136.81,60.76 v2(136.81,61.25) ; R90697.2 93.45,28.1 93.84,27.72 94.47,27.72 94.8,27.38 v2(95.13,27.38)
  IN2 w0.058: v2(95.13,27.38) 95.13,27.03 96.04,26.12 96.04,25.59 96.56,25.07 96.56,24.52 96.3,24.26 96.3,23.22 97.77,21.76 103.29,21.76 104.86,23.32 104.86,23.68 106.48,25.3 107.8,25.3 107.91,25.4 109.12,25.4 109.58,25.86 109.92,25.86 110.32,25.46 111.54,25.46 113.19,23.81 113.62,23.81 114.02,23.41 114.02,22.9 115.44,21.48 115.44,17.85 115.57,17.72 115.57,16.05 115.3,15.78 115.3,14.64 115.83,14.1 117.56,14.1 119.56,16.11 119.56,17.02 120.01,17.47 121.84,17.47 122.29,17.92 123.59,17.92 124.02,18.35 127.17,18.35 127.69,18.88 131.15,18.88 131.48,18.55 132.47,18.55 135.07,21.15 135.39,21.15 135.45,21.2 135.45,21.51 135.5,21.56 135.57,21.56 135.62,21.51 135.62,21.2 135.67,21.15 135.74,21.15 135.8,21.2 135.8,21.51 135.85,21.56 135.92,21.56 135.97,21.51 135.97,21.2 136.02,21.15 136.1,21.15 136.15,21.2 136.15,21.51 136.2,21.56 136.27,21.56 136.32,21.51 136.32,21.2 136.37,21.15 136.45,21.15 136.5,21.2 136.5,21.51 136.55,21.56 136.62,21.56 136.67,21.51 136.67,21.2 136.72,21.15 137.23,21.15 137.7,21.62 140.44,21.62 142.03,23.2 142.03,26.16 142.65,26.79 142.65,28.38 142.12,28.92 142.12,37.1 141.35,37.86 141.35,40.83 137.5,44.68 136.41,44.68 134.6,46.49 134.6,47.1 134.04,47.66 134.04,56.95 133.56,57.44 133.56,59.77 135.04,61.25 v2(136.81,61.25)
MSDC1_DAT0: length 119
  TOP w0.089: v2(94.93,25.3) 93.81,25.3 93.43,24.92 92.88,24.92 92,25.81 92,27.12 91.73,27.39 91.09,27.39 90.84,27.64 90.84,29.39 90.73,29.5 R90699.2
  IN2 w0.058: v2(94.93,25.3) 94.98,25.3 95.08,25.2 95.08,24.65 95.27,24.46 95.27,22.65 95.41,22.51 95.61,22.51 96.29,21.84 96.29,21.6 96.47,21.42 96.7,21.42 96.9,21.23 96.9,20.99 97.13,20.76 104,20.76 107.55,24.31 108.22,24.31 108.32,24.41 111.08,24.41 113.55,21.94 113.57,21.94 114.2,21.31 114.2,14.33 115.44,13.09 117.95,13.09 119.31,14.46 122.39,14.46 125.16,17.23 125.68,17.23 125.81,17.1 132.44,17.1 135.46,20.12 137.98,20.12 139.35,18.75 141.38,18.75 141.99,19.36 141.99,20.48 142.2,20.68 142.2,21.84 143.02,22.67 143.02,25.49 144.18,26.65 144.18,28.41 143.56,29.03 143.56,29.65 143.14,30.08 143.14,39.22 142.56,39.8 142.56,41.23 137.93,45.85 137.3,45.85 135.06,48.09 135.06,57.33 135.44,57.71 135.44,58.9 135.93,59.39 v2(136.2,59.39)
MSDC1_DAT1: length 119
  TOP w0.089: v2(94.9,26.12) 94.6,26.12 94.37,26.35 93.77,26.35 93.29,26.82 93.29,27.11 93.12,27.29 92.77,27.29 91.95,28.1 R90698.2
  IN2 w0.058: v2(135.44,59.39) 135.44,59.24 135.26,59.06 135.26,58.77 135.21,58.72 135.01,58.72 134.96,58.67 134.96,58.6 135.01,58.55 135.21,58.55 135.26,58.5 135.26,57.84 134.88,57.46 134.88,48.02 137.23,45.68 137.85,45.68 142.38,41.15 142.38,39.73 142.96,39.14 142.96,30 143.39,29.57 143.39,28.96 144,28.34 144,26.73 142.84,25.57 142.84,22.75 141.99,21.9 141.99,20.78 141.79,20.58 141.79,19.46 141.28,18.95 139.45,18.95 138.11,20.3 135.39,20.3 132.37,17.28 132.13,17.28 132.07,17.33 132.07,17.56 132.02,17.61 131.95,17.61 131.9,17.56 131.9,17.33 131.85,17.28 131.77,17.28 131.72,17.33 131.72,17.56 131.67,17.61 131.6,17.61 131.55,17.56 131.55,17.33 131.5,17.28 131.42,17.28 131.37,17.33 131.37,17.56 131.32,17.61 131.25,17.61 131.2,17.56 131.2,17.33 131.15,17.28 128.35,17.28 128.3,17.33 128.3,17.43 128.25,17.48 128.18,17.48 128.13,17.43 128.13,17.33 128.08,17.28 128,17.28 127.95,17.33 127.95,17.43 127.9,17.48 127.83,17.48 127.78,17.43 127.78,17.33 127.73,17.28 127.65,17.28 127.6,17.33 127.6,17.43 127.55,17.48 127.48,17.48 127.43,17.43 127.43,17.33 127.38,17.28 127.3,17.28 127.25,17.33 127.25,17.43 127.2,17.48 127.13,17.48 127.08,17.43 127.08,17.33 127.03,17.28 126.95,17.28 126.9,17.33 126.9,17.43 126.85,17.48 126.78,17.48 126.73,17.43 126.73,17.33 126.67,17.28 126.6,17.28 126.55,17.33 126.55,17.43 126.5,17.48 126.43,17.48 126.38,17.43 126.38,17.33 126.32,17.28 126.25,17.28 126.2,17.33 126.2,17.43 126.15,17.48 126.08,17.48 126.03,17.43 126.03,17.33 125.97,17.28 125.89,17.28 125.76,17.41 125.08,17.41 122.31,14.64 119.24,14.64 117.88,13.27 115.51,13.27 114.38,14.4 114.38,17.05 114.43,17.1 114.56,17.1 114.61,17.15 114.61,17.22 114.56,17.28 114.43,17.28 114.38,17.33 114.38,17.4 114.43,17.45 114.56,17.45 114.61,17.5 114.61,17.57 114.56,17.63 114.43,17.63 114.38,17.68 114.38,21.38 113.65,22.11 113.63,22.11 111.15,24.59 108.24,24.59 108.14,24.49 107.42,24.49 103.87,20.94 97.43,20.94 95.45,22.92 95.45,24.53 95.25,24.72 95.25,25.41 95.21,25.45 95.21,25.66 95.25,25.71 95.25,25.95 95.09,26.12 v2(94.9,26.12)
MSDC1_DAT2: length 120.6
  TOP w0.089: R90508.2 R91066.1 135.26,58.73 v2(135.77,58.22) ; v1(90.31,27.79) 89.52,27.79 89.24,28.07 R90701.2
  IN1 w0.076: v1(90.31,27.79) 89.9,27.39 89.9,25.1 90.48,24.52 90.86,24.52 92.13,23.25 92.13,22.41 93.86,20.68 95.36,20.68 95.74,21.06 95.74,21.75 95.82,21.82 v2(95.82,21.85)
  IN2 w0.058: v2(135.77,58.22) 135.77,57.79 135.26,57.28 135.26,48.14 137.37,46.03 138.01,46.03 142.73,41.31 142.73,39.87 143.32,39.29 143.32,30.16 143.74,29.73 143.74,29.1 144.36,28.48 144.36,26.57 143.2,25.41 143.2,22.59 142.4,21.8 142.4,20.58 142.2,20.38 142.2,19.26 141.49,18.55 139.25,18.55 137.85,19.95 135.54,19.95 132.52,16.92 125.74,16.92 125.61,17.05 125.24,17.05 122.46,14.28 119.38,14.28 118.02,12.92 115.37,12.92 114.03,14.26 114.03,21.24 113.5,21.76 113.48,21.76 111.01,24.24 108.39,24.24 108.29,24.14 107.65,24.14 104.1,20.58 97.06,20.58 95.82,21.82 v2(95.82,21.85)
MSDC1_DAT3: length 121
  TOP w0.089: R90700.2 91.92,29.74 92.05,29.61 92.22,29.61 92.34,29.5 92.34,28.3 92.93,27.7 93.26,27.7 93.94,27.03 94.29,27.03 94.75,26.57 v2(94.75,26.52)
  IN2 w0.058: v2(94.75,26.52) 94.93,26.52 95.43,26.03 95.43,24.8 95.62,24.6 95.62,23 97.5,21.12 103.77,21.12 107.32,24.66 108.07,24.66 108.17,24.76 111.22,24.76 113.7,22.29 113.72,22.29 114.55,21.45 114.55,21.23 114.61,21.17 114.73,21.17 114.78,21.12 114.78,21.05 114.73,21 114.61,21 114.55,20.95 114.55,20.87 114.61,20.82 114.73,20.82 114.78,20.77 114.78,20.7 114.73,20.65 114.61,20.65 114.55,20.6 114.55,20.52 114.61,20.47 114.73,20.47 114.78,20.42 114.78,20.35 114.73,20.3 114.61,20.3 114.55,20.25 114.55,20.17 114.61,20.12 114.73,20.12 114.78,20.07 114.78,20 114.73,19.95 114.61,19.95 114.55,19.9 114.55,19.82 114.61,19.77 114.73,19.77 114.78,19.72 114.78,19.65 114.73,19.6 114.61,19.6 114.55,19.55 114.55,19.47 114.61,19.42 114.73,19.42 114.78,19.37 114.78,19.3 114.73,19.25 114.61,19.25 114.55,19.19 114.55,19.12 114.61,19.07 114.73,19.07 114.78,19.02 114.78,18.95 114.73,18.9 114.61,18.9 114.55,18.84 114.55,18.77 114.61,18.72 114.73,18.72 114.78,18.67 114.78,18.6 114.73,18.54 114.61,18.54 114.55,18.49 114.55,18.42 114.61,18.37 114.73,18.37 114.78,18.32 114.78,18.25 114.73,18.19 114.61,18.19 114.55,18.14 114.55,18.07 114.61,18.02 114.73,18.02 114.78,17.97 114.78,17.07 114.55,16.84 114.55,14.48 115.59,13.45 117.8,13.45 119.17,14.81 122.24,14.81 123.83,16.41 123.83,16.48 123.54,16.77 123.54,16.84 123.6,16.89 123.67,16.89 123.96,16.6 124.03,16.6 124.08,16.65 124.08,16.73 123.79,17.01 123.79,17.09 123.84,17.14 123.92,17.14 124.2,16.85 124.28,16.85 124.33,16.9 124.33,16.97 124.04,17.26 124.04,17.33 124.09,17.39 124.16,17.39 124.45,17.1 124.52,17.1 124.57,17.15 124.57,17.22 124.29,17.51 124.29,17.58 124.34,17.63 124.41,17.63 124.7,17.35 124.77,17.35 125.14,17.71 128.37,17.71 128.63,17.46 130.74,17.46 131.1,17.81 132.65,17.81 135.31,20.48 138.21,20.48 138.5,20.19 138.57,20.19 138.67,20.28 138.74,20.28 138.79,20.23 138.79,20.16 138.7,20.06 138.7,19.99 138.75,19.94 138.82,19.94 138.91,20.03 138.99,20.03 139.04,19.98 139.04,19.91 138.95,19.82 138.95,19.74 139.53,19.16 141.18,19.16 141.59,19.56 141.59,20.68 141.79,20.88 141.79,21.95 142.67,22.82 142.67,25.64 143.83,26.8 143.83,28.27 143.21,28.88 143.21,29.32 142.78,29.75 142.78,39.08 142.21,39.66 142.21,41.07 137.78,45.5 137.15,45.5 134.71,47.95 134.71,57.41 v2(134.48,57.64)
MT6358_HPL: length 161.4
  TOP w0.254: v1(15.05,24.31) 16.25,25.52 R90777.1 ; v2(116.83,15.36) 116.62,15.15 116.62,15.04 116.44,14.86 116.44,14.16 116.09,13.81 116.09,12.43 114.74,11.08 v1(114.74,10.19) ; v1(115.43,24.42) 112.63,24.42 111.84,25.2 107.95,25.2 107.52,24.78 106.49,24.78 106.13,25.14 R90773.2
  IN1 w0.254: v1(115.43,24.42) 115.43,24.12 116.34,23.21 116.34,18.98 v2(116.8,18.52) ; v1(114.74,10.19) 114.74,9.67 112.65,7.58 92.62,7.58 91.96,8.24 87.56,8.24 84.81,10.98 80.18,10.98 74.96,5.76 74.96,4.58 73.34,2.95 63.35,2.95 62.26,4.04 58.39,4.04 57.77,4.66 55.18,4.66 53.01,2.49 19.83,2.49 18.39,3.93 18.39,7.81 14.97,11.23 14.97,12.4 11.58,15.79 11.58,21.53 11.13,21.97 11.13,23.22 11.64,23.73 14.46,23.73 v1(15.05,24.31)
  IN2 w0.254: v2(116.83,15.36) 116.83,18.49 v2(116.8,18.52)
MT6358_HPR: length 172
  TOP w0.254: R90774.2 107.18,25.53 107.62,25.97 112.19,25.97 112.97,25.19 115.84,25.19 116.21,24.82 v1(116.21,24.44) ; v1(115.55,10.19) 115.55,10.72 116.87,12.05 116.87,13.5 117.21,13.84 117.21,14.57 v2(117.36,14.71)
  IN1 w0.254: v1(116.21,24.44) 116.21,24.42 117.1,23.53 117.1,19.39 v2(117.28,19.21) ; v1(6.71,36.2) 5.65,35.14 5.65,26.07 7.17,24.54 7.17,23.83 8.8,22.21 9.81,22.21 10.82,21.2 10.82,15.46 14.19,12.08 14.19,10.92 17.62,7.5 17.62,3.61 19.52,1.72 53.38,1.72 55.56,3.89 57.44,3.89 58.06,3.27 61.93,3.27 63.02,2.18 73.67,2.18 75.73,4.24 75.73,5.45 80.49,10.21 84.5,10.21 87.25,7.45 91.66,7.45 92.21,6.9 113.08,6.9 115.55,9.38 v1(115.55,10.19)
  IN2 w0.254: v2(117.28,19.21) 117.6,18.89 117.6,14.95 v2(117.36,14.71)
MT8183_KPCOL0: length 89.3
  TOP w0.089: v2(79.05,29.72) 79.1,29.72 TP9080.1 ; R90874.1 38.02,3.82 v1(36.84,3.82)
  IN1 w0.06: v7(81.83,35.16) 81.78,35.16 80.92,34.3 80.2,34.3
  IN1 w0.076: v2(79.05,29.72) 79.05,29.74 78.85,29.94 78.85,30.61 79.29,31.04 79.29,32.54 80.07,33.33 80.07,34.17 80.2,34.3 ; v1(36.84,3.82) 34.93,3.82 34.37,4.37 34.37,6.31 36.46,8.39 v2(36.46,14.61)
  IN2 w0.058: v3(36.51,14.94) 36.48,14.92 36.48,14.64 v2(36.46,14.61) ; v2(79.05,29.72) 78.6,30.18 78.6,30.65 77.95,31.3 77.63,31.3 77.43,31.5 76.51,31.5 76.39,31.63 76.16,31.63 75.95,31.83 75.95,32.42 73.43,34.94 72.62,34.94 72.3,35.26 71.53,35.26 71.36,35.44 67.41,35.44 66.72,34.75 60.77,34.75 59.93,35.59 52.92,35.59 52.39,35.06 47.15,35.06 46.25,34.15 43.46,34.15 43.14,33.83 42.31,33.83 42.09,33.61 40.24,33.61 39.1,32.47 38.14,32.47 37.04,31.38 v3(36.64,31.38)
  IN4 w0.058: v3(36.51,14.94) 36.14,15.31 35.8,15.31 35.05,16.07 35.05,23.47 36.36,24.78 36.36,28.89 36.81,29.34 36.81,31.2 v3(36.64,31.38)
OVCUR1_L: length 1.2
  TOP w0.089: R91324.2 68.46,31.4 68.44,31.38 U6546.25
OVCUR4_L: length 1.6
  TOP w0.089: U6546.19 71.7,28.57 R91325.2
PANEL_BL_PWM_3V3: length 7.1
  TOP w0.089: Q706.3 43.54,40.78 v2(43.24,41.08)
  IN2 w0.058: v3(43.24,40.75) v2(43.24,41.08)
  IN4 w0.058: v3(43.24,40.75) 43.06,40.58 43.06,40.39 43.44,40.01 43.65,40.01 45.55,38.11 v5(45.55,37.8)
  BOTTOM w0.089: J15.24 v5(45.55,37.8)
PMIC_CLK_WCN: length 89.1
  TOP w0.089: v2(114.77,34.17) 114.97,34.38 C10374.1 R90435.2
  IN2 w0.058: 77.99,54.95 77.99,52.32 77.28,51.62 77.28,46 78.85,44.43 78.85,44.19 80.82,42.22 80.82,42.11 81.26,41.67 81.54,41.67 ; v3(117.25,37.01) 117.13,37.01 115.96,35.85 115.96,35.36 115.79,35.2 115.31,35.2 114.92,34.8 114.92,34.32 v2(114.77,34.17) ; v3(115.17,56.78) 114.89,57.05 114.89,57.74 111.46,61.17 106.51,61.17 106.29,61.39 96.77,61.39 95.66,60.27 80.35,60.27 79.73,59.65
  IN2 w0.06: v8(83.43,41.16) 83.27,41.16 83.14,41.29 82.75,41.29 82.24,41.8 81.69,41.8 81.56,41.67 81.54,41.67 ; 79.73,59.65 78.24,58.16 78.24,55.54 77.99,55.28 77.99,54.95
  IN3 w0.102: v3(117.25,37.01) 117.25,38.26 117.46,38.46 117.46,39.79 118.99,41.32 118.99,45.5 118.74,45.75 118.74,47.51 117.66,48.59 117.66,49.98 117.03,50.62 117.03,54.58 115.17,56.44 v3(115.17,56.78)
PMIC_EC_RESETB: length 46.9
  TOP w0.089: v2(116.7,29.47) 116.46,29.24 116.46,28.83 115.27,27.64 108.77,27.64 108.45,27.96 106.7,27.96 106.56,27.82 105.32,27.82 104.91,28.23 104.91,29.29 104.53,29.67 104.53,30.19 v2(104.07,30.65) ; U2001.D4 104.89,36.85 v2(104.76,36.72) ; R90892.1 126.52,46.39 126.74,46.18 126.74,44.89 125.36,43.52 125.36,42.91 124.9,42.45 123.58,42.45 122.67,41.54 120.09,41.54 118.83,40.28 118.83,32.21 v2(118.93,32.11)
  IN2 w0.058: v2(104.07,30.65) 104.1,30.65 104.5,31.04 104.63,31.04 104.94,31.35 104.94,35.68 105.11,35.85 105.11,36.38 104.78,36.72 v2(104.76,36.72) ; v2(118.93,32.11) 118.93,31.86 117.53,30.46 117.53,30.31 v2(116.7,29.47)
PMIC_EN_ODL: length 49.9
  TOP w0.089: v2(116.82,46.89) 116.21,46.89 115.93,46.61 D2707.1 115.58,44.1 114.87,43.39 114.87,42.5 115.38,41.99 115.78,41.99 115.91,41.87 116.39,41.87 116.59,41.66 116.59,30.25 116.14,29.8 116.14,28.86 115.17,27.9 108.86,27.9 108.55,28.2 106.54,28.2 106.41,28.07 105.55,28.07 105.16,28.45 105.16,29.18 105.42,29.43 105.42,30.86 R90606.2 ; v2(127.77,49.23) 127.58,49.42 U6517.C1
  IN2 w0.058: v2(127.77,49.23) 127.77,48.72 127.9,48.6 127.9,47.28 127.71,47.1 126.5,47.1 126.03,46.63 124.84,46.63 124.52,46.95 122.75,46.95 122.17,46.36 118.04,46.36 117.51,46.89 v2(116.82,46.89)
PMIC_FORCE_RESET: length 111.9
  TOP w0.089: U6559.38 136.78,17.68 136.36,17.25 v2(136.36,17.15)
  IN2 w0.058: v2(136.36,17.15) 136.36,15.86 133.99,13.49 133.13,13.49 132.95,13.67 128.86,13.67 128.28,13.08 127.22,13.08 127,12.86 124.17,12.86 120.93,9.63 119.38,9.63 118.36,8.61 92.1,8.61 89.05,11.66 86.59,11.66 85.65,12.59 81.25,12.59 79.69,12 78.28,11.4 74.73,7.84 70.01,7.84 69.35,8.5 68.82,8.5 68.26,7.95 66.97,7.95 66.42,8.5 64.53,8.5 64.06,8.04 63.07,8.04 v3(62.62,8.49)
  IN4 w0.058: v4(60.84,9.73) 60.84,9.57 61.41,9 62.05,9 62.56,8.49 v3(62.62,8.49)
  IN5 w0.076: v4(60.84,9.73) 60.87,9.71 61.7,9.71 62.06,10.06 62.06,13.11 61.55,13.62 60.59,13.62 58.96,15.25 58.96,15.66 58.17,16.45 58.17,16.63 55.87,18.93 55.87,20.27 56.18,20.58 56.92,20.58 57.26,20.92 58.35,20.92 58.46,21.03 60.69,21.03 61.13,21.48 61.97,21.48 62.88,22.39 v5(65.01,22.39)
  BOTTOM w0.089: R90792.1 v5(65.01,22.39)
PP1000_MIPIBRDG: length 19.7
  TOP w0.508: 66.38,47.61 68.46,47.61 68.77,47.3 71.71,47.3 72.53,46.49 72.53,42.2 73.29,41.43 73.29,41.05 73.39,40.95 73.39,34.98 73.19,34.78 73.19,34.63 72.65,34.09
PP1000_MIPIBRDG_A: length 8.7
  TOP w0.508: R91236.1 64.9,46.76 63.03,44.89 v6(63.03,44.56)
  IN2 w0.254: v2(64.46,42.62) 64.38,42.62 v3(64.17,42.83) ; v2(64.46,43.02) 64.36,43.02 v3(64.17,42.83) ; v3(64.17,42.83) 63.66,42.32 v2(63.66,42.22) ; v3(65.82,43.03) 65.82,42.98 65.66,42.82 v2(65.66,42.62)
  IN4 w0.254: v3(65.82,43.03) 65.82,42.98 65.46,42.63 v5(65.46,42.57) ; v5(64.73,42.57) 64.57,42.73 64.27,42.73 v3(64.17,42.83)
  BOTTOM w0.508: C10685.1 63.39,42.9 63.03,43.26 v6(63.03,44.56)
PP1000_MIPIBRDG_D: length 7.6
  TOP w0.508: R91237.1 v6(68.11,46.95)
  IN2 w0.254: v2(64.86,43.02) 64.86,43.41 v3(64.75,43.52) ; v2(65.26,42.62) v2(65.26,43.02) 65.26,43.36 v3(65.41,43.52)
  IN4 w0.254: v5(65.36,43.19) 65.36,43.47 v3(65.41,43.52) ; v5(64.63,43.19) 64.63,43.39 v3(64.75,43.52)
  BOTTOM w0.508: v6(68.11,46.95) 68.11,44.89 67.39,44.18 66.56,44.18 66.24,43.86 C10682.1
PP1000_MIPIBRDG_EN: length 103.8
  TOP w0.06: U1001.AH26 90.64,33.13 v7(90.58,33.08)
  IN1 w0.06: 90.36,32.29 90.36,32.85 v7(90.58,33.08)
  IN1 w0.076: v1(72.12,39.2) 71.71,39.2 71.17,38.66 68.08,38.66 66.81,39.93 64.43,39.93 63.6,39.1 61.44,39.1 61.02,38.68 61.02,37.98 61.58,37.42 v2(61.58,36.33) ; v2(93.71,23.5) 93.91,23.7 93.91,24.31 93.28,24.95 93.05,24.95 92.03,25.96 92.03,27.22 91.73,27.52 91.73,28.41 90.84,29.3 90.84,30.49 90.36,30.97 90.36,32.29
  IN2 w0.058: v2(93.71,23.5) 89.08,18.87 87.83,18.87 86.92,17.96 83.8,17.96 83.68,17.84 77.45,17.84 76.18,19.11 75.7,19.11 75.09,18.49 75.09,17.13 75.55,16.68 75.55,14.12 74.2,12.78 73.16,12.78 72.99,12.6 66.71,12.6 65.87,13.44 v3(65.31,13.44) ; v3(61.76,35.9) 61.7,35.9 61.58,36.02 v2(61.58,36.33)
  IN4 w0.058: v4(61.6,12.53) 61.6,12.83 62.21,13.44 v3(65.31,13.44) ; v4(61.5,35.13) 61.5,35.31 61.76,35.57 v3(61.76,35.9)
  IN5 w0.076: v4(61.6,12.53) 61.03,12.53 58.5,15.06 58.5,15.47 57.71,16.26 57.71,16.44 55.42,18.74 55.42,18.97 54.7,19.68 53.66,19.68 53.49,19.85 53.49,20.1 53.03,20.56 53.03,21.79 53.03,21.79 53.03,24.44 53.95,25.36 59.88,25.36 61.63,27.11 61.63,35.01 v4(61.5,35.13)
PP1800_ALW: length 138.1
  TOP w0.254: R91228.2 67.93,52.9 67.93,49.03 67.72,48.82 63.31,48.82 63.23,48.9 60.56,48.9 59.42,47.76 58.56,47.76 56.56,45.75 v2(55.13,45.75) v2(54.59,45.75) ; v6(69.99,4.12) 69.78,3.92 65.67,3.92 65.26,4.32 64.56,4.32 63.76,3.52 63.16,3.52 62.77,3.91 62.77,5.9 63,6.12 63,11.69 v6(62.85,11.84)
  IN2 w0.152: 29.98,39.58 29.98,40.47 32.88,43.36 35.93,43.36
  IN2 w0.254: v6(31.28,33.94) 31.28,35.77 30.87,36.18 29.5,36.18 28.71,36.96 28.71,38.31 29.98,39.58 ; v2(55.13,45.75) v2(54.59,45.75) 53.42,45.75 53.05,46.13 45.13,46.13 45.03,46.03 42.87,46.03 42.57,46.34 40.29,46.34 39.27,45.32 38.69,45.32 38.11,44.74 37.31,44.74 35.93,43.36 ; v3(15.15,29.85) 15.15,29.95 v2(14.97,30.13)
  IN3 w0.254: v3(15.15,29.85) 15.45,30.15 15.45,30.25 16.46,31.26 18.36,31.26 18.7,31.6 23.35,31.6 23.73,31.22 24.7,31.22 24.95,31.48 24.95,32.49 26.65,34.19 28.64,34.19 29.11,33.73 31.06,33.73 v6(31.28,33.94) 31.45,33.94 32.69,32.71 v3(34.9,32.71)
  IN4 w0.254: v3(34.9,32.71) 34.83,32.77 v5(34.5,32.77)
  BOTTOM w0.254: v6(62.85,11.84) 61.1,11.84 60.36,12.58 58.63,12.58 58.07,13.14 57.63,13.14 56.31,14.46 56.14,14.46 55.74,14.86 55.74,20.62 54.06,22.31 52.47,22.31 52.13,22.65 51.02,22.65 50.25,23.42 42.12,23.42 39.83,25.72 39.17,25.72 37.5,27.38 37.5,29.57 34.5,32.57 v5(34.5,32.77)
  vias: v5(86.01,12.86) v5(86.22,13.06) v5(86.42,12.86) v5(86.62,13.06) v5(86.83,12.86) v5(87.03,13.06) v5(87.23,12.86) v5(87.44,13.06) v6(128,13.54) v6(128.55,14.01) v6(135.01,65.9) v6(141.36,46.84) v6(142.07,46.84)
PP1800_ALW_N: length 49.6
  IN2 w0.076: v6(85.43,15.5) 85.68,15.25 85.68,14.99 85.89,14.78 86.23,14.78 87.31,13.7 93.06,13.7 93.87,12.88 98.78,12.88 99.36,12.3 101.77,12.3 102.11,11.95 113.21,11.95 113.63,11.53 114.95,11.53 115.2,11.28 117.9,11.28 119.81,13.19 123.11,13.19 125.22,15.3 125.86,15.3 125.94,15.22 v2(125.94,14.99)
  BOTTOM w0.076: v6(85.43,15.5) 85.43,15.37 85.61,15.2 85.61,15.02 85.53,14.94 85.12,14.94 84.97,15.09 84.97,15.83 85.38,16.23 85.38,18.08 85.45,18.15 85.62,18.15 NC295.2
PP1800_ALW_P: length 50.2
  IN2 w0.076: v2(125.94,15.75) 125.94,15.53 125.86,15.45 125.15,15.45 123.05,13.34 119.75,13.34 117.84,11.43 115.27,11.43 115.01,11.68 113.69,11.68 113.27,12.1 102.18,12.1 101.83,12.45 99.43,12.45 98.84,13.04 93.94,13.04 93.12,13.85 87.37,13.85 86.29,14.93 85.96,14.93 85.83,15.06 85.83,15.2 v6(86.14,15.5)
  BOTTOM w0.076: NC296.2 85.62,18.31 85.39,18.31 85.23,18.14 85.23,16.3 84.82,15.89 84.82,15.03 85.06,14.79 85.59,14.79 85.76,14.95 85.76,15.12 v6(86.14,15.5)
PP1800_AP: length 80.5
  TOP w0.152: Q777.5 45.98,48.16 45.83,48.31 45.34,48.31 v1(45.27,48.24) ; v2(51.9,4.83) 51.9,4.45 51.39,3.94 Q734.1 ; v1(42.25,46.34) 42.25,46.44 42.4,46.59 Q776.5 ; Q779.5 53.37,47.63 53.15,47.41 R91131.1 ; R1106.1 v1(78.09,35.19) ; v1(48.75,47.91) 49.13,47.91 49.41,47.63 Q778.5 ; R1104.2 77.99,33.51 v1(77.96,33.53)
  TOP w0.254: 76.59,38.96 77.36,38.96 77.89,38.44 R1109.1 R1110.1 ; 76.59,38.96 76.59,42.19 76.98,42.58 R90626.2 R90625.2 ; 76.59,38.96 76.59,38.73 76.52,38.66 R1102.1 R1101.1 76.52,37.01 76.46,36.95 v1(76.46,36.92) ; v1(76.27,35.3) 76.27,33.75 76.6,33.42 76.6,33.19 R90461.2 76.11,32.13 R1103.2 75.85,31.56 75.85,29.04 78.09,26.8 81.19,26.8 81.55,27.16 83.87,27.16 ; v1(60.24,47.33) 60.99,48.07 62.66,48.07 63.56,47.17 R91238.1
  IN2 w0.152: v2(36.71,22.24) 36.71,22.31 v3(36.94,22.54) ; v2(119.19,47.43) 118.7,47.43 v3(116.65,49.49) ; v3(38.72,21.52) 38.72,20.99 v2(38.66,20.94) ; v2(36.71,16.39) 36.36,16.03 v3(35.92,16.03) ; v3(52.26,4.83) v2(51.9,4.83) ; v3(38.92,17.4) 38.92,17.43 v2(38.66,17.69) ; v3(41.33,7.72) v2(41,7.72)
  IN2 w0.254: v3(41.89,45.33) v2(41.46,45.33) ; v2(107.7,34.54) 107.81,34.44 v3(107.81,34.22)
  IN4 w0.152: v3(38.72,21.52) 38.74,21.49 39.25,21.49 39.4,21.65 39.99,21.65 v5(40.09,21.75) ; v4(51.9,6.76) 51.9,5.27 52.26,4.91 v3(52.26,4.83) ; v5(37.37,22.56) 36.96,22.56 v3(36.94,22.54) ; v4(41.79,7.72) v3(41.33,7.72)
  IN4 w0.254: v4(41.41,38.79) v3(41.41,39.2) 41.41,39.55 41.16,39.81 40.52,39.81 39.39,40.94 34.43,40.94 33.05,42.32 33.05,42.75 33.28,42.98 36.99,42.98 38.29,44.28 40.84,44.28 v3(41.89,45.33) ; v3(79.97,25.99) 79.98,25.98 v4(80.34,25.98) ; v5(112.58,35.93) v3(112.32,35.67) ; v4(40.83,38.86) v3(40.83,39.19)
  IN5 w0.254: v4(80.34,25.98) 80.75,26.4 80.75,29.39 81.22,29.86 v5(82.38,29.86)
  BOTTOM w0.152: Q4.5 v5(27.59,17.91) ; Q3.5 v5(24.62,19.01)
  BOTTOM w0.254: v5(82.38,29.86) R90463.1
  vias: v1(41.74,39.43) v1(52.64,47.38) v1(81.03,25.67) v1(83.68,27.49) v1(83.68,27.22) v1(83.68,26.96) v1(83.93,27.31) v1(83.93,27.06) v1(88.12,25.87) v1(88.12,25.62) v1(88.17,26.17) v1(88.43,26.15) v1(88.4,25.9) v1(88.37,25.64) v2(41.74,39.43) v2(77.71,32.26) v2(77.73,31.97) v2(77.73,31.71) v2(77.96,32.26) v2(77.99,31.97) v2(81.03,25.67) v2(83.68,27.49) v2(83.68,27.22) v2(83.68,26.96) v2(83.93,27.31) v2(83.93,27.06) v2(88.12,25.87) v2(88.12,25.62) v2(88.17,26.17) v2(88.43,26.15) v2(88.4,25.9) v2(88.37,25.64) v3(40.04,14.94) v3(40.45,14.94) v3(84.26,27.03) v3(84.67,27.03) v3(87.87,26.5) v3(88.27,26.5) v3(88.68,26.5) v3(108.11,31.38) v3(108.09,30.97) v3(114,33.79) v3(114,33.36) v4(40.75,15.07) v4(40.75,14.81) v4(41,15.07) v4(41,14.81) v4(89.03,26.17) v4(89.09,26.51) v4(89.26,26.28) v4(89.39,26.51) v4(107.78,31.45) v4(107.83,31.2) v4(107.88,30.7) v4(108.14,30.62) v5(44.69,13.1) v5(89.03,26.17) v5(89.09,26.51) v5(89.26,26.28) v5(89.39,26.51) v5(107.78,31.45) v5(107.83,31.2) v5(107.88,30.7) v5(108.14,30.62) v6(25.48,36.07) v6(26.22,36.07) v6(95.18,33.76) v6(110.19,54.73) v6(110.9,54.73)
