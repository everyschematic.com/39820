# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Nets (continued)
D_GND: C1.2 C2.2 C3.2 C4.2 C6.2 C7.2 C8.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C44.2 C45.2 C46.2 C141.2 C175.2 C238.2 C239.2 C240.1 C246.2 C251.2 C299.2 C368.1 C375.2 C412.2 C414.2 C415.2 C431.2 C434.1 C436.1 C437.1 C438.2 C439.1 C444.2 C457.2 C487.2 C491.2 C492.1 C493.2 C495.2 C503.2 C504.2 C518.2 C533.1 C594.2 C748.2 C749.2 C1001.1 C1002.2 C1003.2 C1004.2 C1005.1 C1006.2 C1009.1 C1010.1 C1011.1 C1502.2 C1503.2 C1701.1 C1702.1 C1703.1 C1704.1 C1706.1 C1707.1 C1709.1 C1808.1 C1810.1 C1811.2 C1812.1 C1813.1 C1814.1 C1815.1 C1816.1 C1817.1 C1818.2 C1819.1 C1820.2 C1821.1 C1822.1 C1823.1 C1824.2 C1825.2 C1826.1 C1827.1 C1828.1 C1829.1 C1830.2 C1831.2 C1832.2 C1833.2 C1834.2 C1835.2 C1836.1 C1837.1 C1838.2 C1839.2 C1840.1 C1841.1 C1842.1 C1843.1 C2002.2 C2003.1 C2005.2 C2008.2 C2010.1 C2011.1 C2021.2 C2026.2 C2027.2 C2029.2 C2030.2 C2031.2 C2032.2 C2101.2 C2102.2 C2103.2 C2105.2 C2106.2 C2108.2 C2111.2 C2112.2 C2113.2 C2116.2 C2117.2 C2120.2 C2121.2 C2124.2 C2125.2 C2129.2 C2130.2 C2132.2 C2133.2 C2134.2 C2135.2 C2136.2 C2141.2 C2142.2 C2144.2 C2145.2 C2146.2 C2147.2 C2148.2 C2149.2 C2302.2 C2303.2 C4004.2 C4005.2 C4006.2 C4007.2 C4011.2 C4012.2 C4013.2 C4014.2 C4101.1 C4202.1 C4203.2 C4301.1 C4302.2 C4401.1 C4402.1 C4403.2 C4404.1 C4405.1 C4406.1 C4407.2 C4408.2 C4409.2 C4410.2 C4411.2 C4412.2 C4413.2 C4414.2 C4415.2 C4416.2 C4417.2 C4418.2 C4419.1 C4420.2 C4421.2 C4422.2 C4423.2 C4424.2 C4425.2 C4426.2 C4427.2 C5001.1 C5002.1 C6209.1 C6221.2 C6324.1 C6329.1 C6401.2 C6404.1 C6701.2 C6702.2 C6901.2 C7101.1 C7102.2 C7104.2 C7210.2 C7405.1 C7406.1 C7407.1 C8001.2 C8201.2 C8202.2 C9016.2 C9017.2 C9018.1 C9019.1 C9020.2 C9021.1 C9022.2 C9023.1 C9048.2 C9049.2 C9050.2 C9051.2 C9052.2 C9055.1 C9056.2 C9057.2 C9058.2 C9061.1 C9063.1 C9066.1 C9067.2 C10350.2 C10354.2 C10355.2 C10356.2 C10357.2 C10358.2 C10359.1 C10365.2 C10367.2 C10368.2 C10370.2 C10372.2 C10373.2 C10374.2 C10378.2 C10380.1 C10381.2 C10382.2 C10383.2 C10384.2 C10393.1 C10394.2 C10395.2 C10396.2 C10399.2 C10412.1 C10413.2 C10420.2 C10421.2 C10422.2 C10423.2 C10424.2 C10425.2 C10427.2 C10428.2 C10430.2 C10431.2 C10432.2 C10433.2 C10437.2 C10438.2 C10439.2 C10440.2 C10442.2 C10443.2 C10445.1 C10446.2 C10447.2 C10448.1 C10449.1 C10451.2 C10452.2 C10453.2 C10454.1 C10455.2 C10456.2 C10457.2 C10458.2 C10460.2 C10461.2 C10462.2 C10468.2 C10469.1 C10472.1 C10473.1 C10474.2 C10475.2 C10478.2 C10479.2 C10480.1 C10481.1 C10482.2 C10483.2 C10484.2 C10485.2 C10486.2 C10488.2 C10489.2 C10491.2 C10492.2 C10493.2 C10494.2 C10495.2 C10496.2 C10499.2 C10500.2 C10501.2 C10502.1 C10503.1 C10504.1 C10505.2 C10508.2 C10525.1 C10533.1 C10534.2 C10535.1 C10538.2 C10539.1 C10540.2 C10550.2 C10551.2 C10552.2 C10566.2 C10570.2 C10571.1 C10575.2 C10576.2 C10604.2 C10605.2 C10606.2 C10610.1 C10613.2 C10614.2 C10619.2 C10620.2 C10621.2 C10622.1 C10623.1 C10624.2 C10627.1 C10628.2 C10629.2 C10631.2 C10632.2 C10634.2 C10635.2 C10636.2 C10637.2 C10638.2 C10639.1 C10640.1 C10641.2 C10642.2 C10644.1 C10647.2 C10660.2 C10662.2 C10663.2 C10664.2 C10665.1 C10666.2 C10667.2 C10668.1 C10670.2 C10671.2 C10672.2 C10673.2 C10674.1 C10675.2 C10676.2 C10677.1 C10678.2 C10679.2 C10680.1 C10681.2 C10682.2 C10683.1 C10684.2 C10685.2 C10686.1 C10687.2 C10688.2 C10689.2 C10690.2 C10691.2 C10692.2 C10693.2 C10694.1 C10695.2 C10696.2 C10697.2 C10698.2 C10709.1 C10710.1 C10711.2 C10712.2 C10713.2 C10714.2 C10715.2 C10716.1 C10717.1 C10718.2 CLIP9.1 CLIP9.2 CLIP9.3 CLIP10.1 CLIP10.2 CLIP10.3 CLIP11.1 CLIP11.2 CLIP11.3 CLIP12.1 CLIP12.2 CLIP12.3 CLIP17.1 CLIP17.2 CLIP17.3 CLIP19.1 CLIP19.2 CLIP19.3 CLIP20.1 CLIP20.2 CLIP20.3 CLIP21.1 CLIP21.2 CLIP21.3 CON12.3 CON12.7 CON12.8(G2) CON15.1 CON15.2 CON15.9 CON15.10 CON16.1 CON16.8 CON16.15 CON16.20 CON16.31 CON16.36 CON16.42 CON6201.5 CON6201.7 CON7101.1 CON7101.2 CON7101.3 CON7101.4 CON7101.A1 CON7101.A12 CON7101.B1 CON7101.B12 CON7102.31 CON7102.32 CON9104.5 CON9104.6 CON9105.31 CON9105.32 D1.2 D2711.2 D2712.2 D2713.2 D2714.2 D2715.2 D2716.2 D2717.2 D2718.2 D2719.2 D2720.2 D2721.2 D2722.2 D2723.2 D2724.2 D2725.2 D2726.2 D2727.2 D2728.2 D2729.2 D2730.2 D2731.2 D2732.2 D2733.2 D2734.2 D2740.2 D2741.3 D2742.2 D2743.2 ESD6204.1 ESD6206.1 ESD6309.2 ESD6310.2 ESD7102.2 ESD7502.2 ESD7505.2 ESD7506.2 ESD7507.1 ESD7508.1 ESD7509.1 ESD7511.2 HOLE8.1 HOLE9.1 HOLE10.1 HOLE11.1 HOLE12.1 HOLE13.1 HOLE14.1 HOLE15.1 HOLE16.1 HOLE19.1 HOLE20.1 J15.2 J15.5 J15.9 J15.12 J15.15 J15.18 J15.21 J15.25 J15.40 J15.41 J15.42 J17.8 J17.10 J17.11 J17.14 J17.15 J17.17 J17.18 J17.21 J17.22 J20.1 J20.7 J20.8 J24.6 J24.7 J24.8 NTC1501.2 NTC1502.2 PC18.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PQ1.5 PQ1.6 PQ1.7(S2#3) PQ2.5 PQ2.6 PQ2.7(S2#3) PU1.2 Q2.1(S) Q55.1(S) Q718.1(S) Q748.1(S) Q766.2(S) Q791.1(S) Q792.1(S) Q795.1(S) Q797.1(S) Q798.1(S) Q802.1(S) Q803.1(S) Q806.2(S) R2.2 R3.2 R15.1 R174.1 R219.2 R405.2 R504.2 R537.1 R940.2 R1004.1 R1010.1 R1011.1 R1012.1 R2204.1 R2205.2 R2206.2 R2303.2 R4001.1 R6206.2 R6207.2 R90266.1 R90375.2 R90409.2 R90415.2 R90416.1 R90423.2 R90434.2 R90448.2 R90450.2 R90597.1 R90673.2 R90692.1 R90707.1 R90726.2 R90728.2 R90732.2 R90741.2 R90782.2 R90810.2 R90811.2 R90853.2 R90854.2 R90859.1 R90897.1 R90898.1 R90899.1 R90900.1 R90901.1 R90906.1 R90913.2 R90974.2 R90983.2 R91029.2 R91057.2 R91061.2 R91062.2 R91064.1 R91092.1 R91093.1 R91094.1 R91097.1 R91142.1 R91144.1 R91146.1 R91156.1 R91157.1 R91158.1 R91159.1 R91185.2 R91192.1 R91231.1 R91242.1 R91245.1 R91251.2 R91258.1 R91267.1 R91269.1 R91274.1 R91282.1 R91283.1 R91284.1 R91285.1 R91286.1 R91287.1 R91288.1 R91289.1 R91290.1 R91321.2 R91322.2 R91323.1 R91325.1 SH1801.1 SH1804.1 SH1805.2 SH1808.1 SH2001.2 SH2140.2 SH2144.2 SH4402.2 SH6101.1 SH6102.1 SH8101.2 SH8102.2 SW7504.2 SW7504.4 TP8273.1 TP8274.1 TP8275.1 U1.89 U2.3 U3.3 U5.A6 U5.B3 U5.B4 U5.D3 U5.D4 U5.G3 U5.G4 U5.J3 U5.J4 U5.K6 U6.33 U12.4 U18.A6 U18.C4 U18.E7 U18.G5 U18.H10 U18.J5 U18.K8 U18.N2 U18.N5 U18.P4 U18.P6 U23.5 U23.7 U49.4 U49.9 U93.33 U124.C2 U124.D4 U124.D5 U124.D6 U124.E4 U124.E5 U124.E6 U124.F4 U124.F5 U124.F6 U124.G2 U1001.A21 U1001.AA12 U1001.AA17 U1001.AA21 U1001.AB8 U1001.AB14 U1001.AB18 U1001.AB21 U1001.AC12 U1001.AC17 U1001.AD8 U1001.AE10 U1001.AE14 U1001.AE15 U1001.AE16 U1001.AF8 U1001.AF9 U1001.AF15 U1001.AG8 U1001.AG9 U1001.AG15 U1001.AH8 U1001.AH9 U1001.AH15 U1001.AH18 U1001.AJ9 U1001.B9 U1001.B13 U1001.B21 U1001.B23 U1001.B25 U1001.C3 U1001.C6 U1001.C10 U1001.C11 U1001.C18 U1001.C19 U1001.C22 U1001.C24 U1001.D3 U1001.D12 U1001.D16 U1001.D21 U1001.E2 U1001.E3 U1001.E4 U1001.E14 U1001.E15 U1001.E26 U1001.F3 U1001.F4 U1001.F5 U1001.F9 U1001.F10 U1001.F11 U1001.F17 U1001.F18 U1001.F19 U1001.G3 U1001.G4 U1001.G5 U1001.G6 U1001.G21 U1001.H2 U1001.H24 U1001.H25 U1001.H26 U1001.J3 U1001.J8 U1001.J10 U1001.J13 U1001.J17 U1001.J23 U1001.J26 U1001.K10 U1001.K14 U1001.K18 U1001.K24 U1001.K25 U1001.K27 U1001.L1 U1001.L9 U1001.L13 U1001.L17 U1001.L24 U1001.M1 U1001.M2 U1001.M3 U1001.M4 U1001.M5 U1001.M10 U1001.M14 U1001.M18 U1001.N1 U1001.N2 U1001.N3 U1001.N4 U1001.N5 U1001.N9 U1001.N13 U1001.N17 U1001.N21 U1001.P1 U1001.P2 U1001.P3 U1001.P4 U1001.P5 U1001.P10 U1001.P14 U1001.P18 U1001.R1 U1001.R2 U1001.R3 U1001.R4 U1001.R5 U1001.R9 U1001.R13 U1001.R17 U1001.R26 U1001.T1 U1001.T2 U1001.T3 U1001.T4 U1001.T5 U1001.T10 U1001.T14 U1001.T21 U1001.U1 U1001.U2 U1001.U3 U1001.U4 U1001.U5 U1001.U13 U1001.U17 U1001.U23 U1001.V1 U1001.V2 U1001.V3 U1001.V4 U1001.V5 U1001.V8 U1001.V9 U1001.V10 U1001.V12 U1001.V14 U1001.V18 U1001.V26 U1001.W1 U1001.W12 U1001.W13 U1001.W17 U1001.W21 U1001.Y8 U1001.Y9 U1001.Y10 U1001.Y14 U1001.Y18 U1007.6 U1007.17 U1007.20 U1007.23 U1007.26 U1007.32 U1007.35 U1007.38 U1007.41 U1007.62 U1007.68 U1007.71 U1007.74 U1007.75 U1007.76 U1007.77 U1007.78 U1007.79 U1007.80 U1007.81 U1007.82 U1007.83 U1007.84 U1007.85 U1007.86 U1007.87 U1007.88 U1007.89 U1007.90 U1007.91 U1007.92 U1007.93 U1007.94 U1007.95 U1007.96 U1007.97 U1007.98 U1007.99 U1007.100 U1007.101 U1007.102 U1007.103 U1007.104 U1007.105 U1007.106 U1007.107 U1007.108 U2001.E8 U2001.E14 U2001.F7 U2001.F8 U2001.F9 U2001.G7 U2001.G8 U2001.G9 U2001.H7 U2001.H8 U2001.H9 U2001.L6 U2001.M5 U2001.N2 U2001.N6 U2001.P2 U2001.R2 U6404.6 U6404.7 U6502.C2 U6503.C2 U6504.B2 U6504.B10 U6504.B12 U6514.B1 U6517.C2 U6517.D4 U6517.D5 U6517.D6 U6517.F1(VSSA) U6522.6 U6522.10 U6522.11 U6522.12 U6522.13 U6524.3 U6524.5 U6524.17 U6525.3 U6525.17 U6526.3 U6526.17 U6528.11 U6528.15 U6530.3 U6530.17 U6531.B1 U6533.C2 U6538.3 U6538.7 U6539.3 U6540.3 U6541.A2 U6541.B2 U6541.D2 U6546.29 U6547.1 U6547.2 U6547.3 U6547.4(VSS) U6547.9 U6548.5 U6552.2 U6553.2 U6554.2 U6555.9 U6558.C3 U6558.D3 U6558.E3 U6559.48 U6559.49 U6563.11 U6563.12 U6563.13 U6563.22 U6563.25 U6569.1 U6570.4 U6570.8 U6571.4 U6571.8 U6572.2 U6573.2 U6574.3 U6575.C5 U6575.E1 U6575.E3 U6576.2 U6577.A2 U6577.B2 U6578.D3 U6578.D4 U6578.D5 U6578.E4 U6579.B1 U6580.2 U6581.2 U6581.4 U6582.B2 UD1.A3 UD1.A10 UD1.AB3 UD1.AB5 UD1.AB8 UD1.AB10(VSS57) UD1.C1 UD1.C5 UD1.C8 UD1.C12 UD1.D2 UD1.D4 UD1.D9 UD1.D11 UD1.E1 UD1.E5 UD1.E8 UD1.E12 UD1.G1 UD1.G3 UD1.G5 UD1.G8 UD1.G10 UD1.G12 UD1.J1 UD1.J3 UD1.J10 UD1.J12 UD1.K2 UD1.K4 UD1.K9 UD1.K11 UD1.N2 UD1.N4 UD1.N9 UD1.N11 UD1.P1 UD1.P3 UD1.P10 UD1.P12 UD1.T1 UD1.T3 UD1.T5 UD1.T8 UD1.T10 UD1.T12 UD1.V1 UD1.V5 UD1.V8 UD1.V12 UD1.W2 UD1.W4 UD1.W9 UD1.W11 UD1.Y1 UD1.Y5 UD1.Y8 UD1.Y12 X8101.2 X8101.4 Y1.2 Y1.4 Y2.2 Y2.4 Y3.2 Y3.4
DA7219_HPL: R90778.1 U6504.A3
DA7219_HPR: R90779.1 U6504.A5
DA7219_INT_ODL: R90561.2 U1001.Y25 U6504.D10
DA7219_MIC: R90332.1 U6504.C15
DA7219_MIC_N: C9054.2 U6504.A15
DA7219_MIC_P: C9053.2 U6504.B16
DA7219_MICBIAS: C9055.2 R90332.2 U6504.B14
DA7219_VDD: C9056.1 R90528.2 U6504.C5
DA7219_VDD_MIC: C9057.1 R90529.2 U6504.A13
DA7219_VDDIO: C9058.1 R90527.2 U6504.D4
DA7219_VMID: C9051.1 U6504.A9
DA7219_VREF: C9050.1 U6504.A7
DEBUG_SPI_FLASH_CS_L: CON16.3 R90425.1 U124.J7
DEBUG_SPI_FLASH_HOLD_L: CON16.7 R334.2 U49.7
DEBUG_SPI_FLASH_MISO: CON16.5 R90424.1 U124.J9
DEBUG_SPI_FLASH_MOSI: CON16.4 R90427.2 U124.D9
DEBUG_SPI_FLASH_SCK: CON16.2 R90426.2 U124.G9
DIOM4_NC: R90377.2 U124.A3
DISP_PWM: Q706.1(S) U1001.AH23
DMIC_CLK: J15.7 U2001.K1
DMIC_DATA_1: R102.1 U2001.L1
DMIC_DATA_1_R: J15.6 R102.2
DP_AUX_N: C9036.2 R1.1 R91282.2 U93.13
DP_AUX_P: C9035.2 R2.1 U93.12
DP_LN0_N: C10704.2 U93.17
DP_LN0_P: C10703.2 U93.18
DP_LN1_N: C10700.2 U93.19
DP_LN1_P: C10699.2 U93.20
DP_LN2_N: C10702.2 U93.21
DP_LN2_P: C10701.2 U93.22
DP_LN3_N: C10706.2 U93.23
DP_LN3_P: C10705.2 U93.24
DPI_CK: R90832.1 U5.C5 U1001.AC25
DPI_D0: R90822.1 U5.D5 U1001.W23
DPI_D1: R90821.1 U5.D6 U1001.AA25
DPI_D2: R90820.1 U5.E5 U1001.W25
DPI_D3: R91150.1 U5.E6 U1001.W26
DPI_D4: R90826.1 U5.F6 U1001.AB26
DPI_D5: R90825.1 U5.F5 U1001.AB23
DPI_D6: R90824.1 U5.G6 U1001.W24
DPI_D7: R90823.1 U5.G5 U1001.Y24
DPI_D8: R90830.1 U5.H6 U1001.AB24
DPI_D9: R90829.1 U5.H5 U1001.Y26
DPI_D10: R90828.1 U5.J6 U1001.AA26
DPI_D11: R90827.1 U5.J5 U1001.AA23
DPI_DE: R90831.1 U5.C6 U1001.AC26
DPI_HSYNC: R90834.1 U5.B6 U1001.Y23
DPI_VSYNC: R90833.1 U5.B5 U1001.AA24
DSI0_CKN: R189.1 U1001.U24
DSI0_CKP: R190.1 U1001.U25
DSI0_D0N: R192.1 U1001.R27
DSI0_D0P: R193.1 U1001.T27
DSI0_D1N: R191.1 U1001.T26
DSI0_D1P: R194.1 U1001.U26
DSI0_D2N: R187.1 U1001.V24
DSI0_D2P: R188.1 U1001.V25
DSI0_D3N: R184.1 U1001.T24
DSI0_D3P: R185.1 U1001.T25
EAR_JACK_GND: R90776.2 SH6204.1 U6541.A4
EAR_MIC_N: C6229.2 C10444.1 C10445.2 R6209.1 R6210.2 R90776.1
EAR_MIC_P: C6209.2 C6221.1 C6230.2 C10444.2 R6210.1 R6225.2 R90738.2 R90781.1
EC_AP_INT_ODL: R90471.2 U1001.L25 U6517.E7
EC_BATT_PRES_ODL: R293.2 R90893.2
EC_BL_EN_OD: D2738.2 D2739.2 Q705.1(S) R91199.2 U6517.A8
EC_BOARD_ID: C10379.1 R90472.1 R90473.1 U6517.E3
EC_BOARD_ID_EN_ODL: C10379.2 R90473.2 U6517.B1
EC_BOOT0: Q8.3 R90449.2 R90450.1 U6517.B4
EC_BOOT_DFU: R90449.1 U124.J5
EC_CCD_MODE_ODL: Q780.1(S) R91147.2 U6517.H2
EC_ENTERING_RW: Q717.3 R90375.1 U124.B5
EC_ENTERING_RW_ODL: Q717.1 R90376.1 U6517.F6
EC_FLASH_WP_ODL: R90610.2 U6517.E8
EC_I2C1_1V8_SCL: Q783.1(S) Q787.1(S) R90521.2 R90603.1 R91117.1 U6517.B3
EC_I2C1_1V8_SDA: Q784.1(S) Q788.1(S) R90522.2 R90604.1 R91118.1 U6517.A3
EC_I2C1_3V3_SCL: Q787.3 R91205.2 R91210.2
EC_I2C1_3V3_SDA: Q788.3 R91204.2 R91211.2
EC_I2C2_1V8_SCL: Q726.3 Q757.1(S) R90524.2 U6517.C8 U6547.6
EC_I2C2_1V8_SDA: Q725.3 Q759.1(S) R90523.2 U6517.B8 U6547.5
EC_I2C2_1V8_SENSOR_SCL: J24.5 Q726.1(S) R90515.2 R91219.1 U6574.2
EC_I2C2_1V8_SENSOR_SDA: J24.4 Q725.1(S) R90514.2 R91220.1 U6574.6
EC_I2C2_3V3_SCL: Q757.3 R91051.2 R91203.2 R91296.1 U6.22
EC_I2C2_3V3_SDA: Q759.3 R91052.2 R91202.2 R91297.1 U6.21
EC_I2C_USB_C0_MUX_SCL: R91293.2 U93.8
EC_I2C_USB_C0_MUX_SCL_R: Q783.3 R941.2 R91293.1
EC_I2C_USB_C0_MUX_SDA: R91294.2 U93.9
EC_I2C_USB_C0_MUX_SDA_R: Q784.3 R942.2 R91294.1
EC_IN_RW_OD: R90463.2 U124.A9 U1001.AA7
EC_KSI: R3003.1 R3004.1 U124.A8
EC_KSI2: R3003.2 R3006.2 U6559.23
EC_KSI3: R3004.2 R3005.2 U6559.19
EC_KSO2_INV: R91160.2 U6559.47
EC_NRST: C10425.1 Q739.4 U6517.E1
EC_PMIC_WATCHDOG_L: R90453.2 U2001.F12 U6517.F3
EC_PROCHOT_ODL: R90868.1 R91191.1
EC_PWR_BTN_ODL: R90460.2 U124.B7 U6517.G2
EC_RST_ODL: Q739.1(S) R90630.2 R90680.2 R90681.2 R90682.2 R90683.1 R90967.1 R91319.2
EC_RST_ODL_Q: Q739.3 Q739.6
EC_RST_ODL_R: R90967.2 U6548.3
EC_RST_R_L: R91319.1 U6581.3
EC_SENSOR_SPI_CK: R91222.1 U6517.G7
EC_SENSOR_SPI_MISO: R91224.1 U6517.F2
EC_SENSOR_SPI_MOSI: R91221.1 U6517.G1
EC_SENSOR_SPI_NSS: R91223.1 U6517.H8
EC_SKU_ID: R90982.2 R90983.1 U6517.F5
EC_SLG_SYS_RST_L: R90582.1 R90966.1 R91142.2 U6517.B6
EC_SLG_SYS_RST_L_R: R90966.2 U6548.2
EC_UART_VREF: C414.1 CON16.34 R90440.1
EDP_AUX_C_N: C229.1 J15.20
EDP_AUX_C_P: C228.1 J15.19
EDP_AUX_N: C229.2 U6578.C2
EDP_AUX_P: C228.2 TP9179.1 U6578.B2
EDP_BL_VOUT: C246.1 C10663.1 F2.2 J15.31 J15.32 J15.33
EDP_HPD: J15.22 Q792.2 R91242.2
EDP_TX0_C_N: C527.1 J15.16
EDP_TX0_C_P: C526.1 J15.17
EDP_TX0_N: C527.2 U6578.A3
EDP_TX0_P: C526.2 U6578.A2
EDP_TX1_C_N: C10509.1 J15.3
EDP_TX1_C_P: C10510.1 J15.4
EDP_TX1_N: C10509.2 U6578.B6
EDP_TX1_P: C10510.2 U6578.B5
EEPROM_WP_OD: Q750.3 U6547.7
EMI0_CA0: U1001.E9 UD1.H2
EMI0_CA1: U1001.C7 UD1.J2
EMI0_CA2: U1001.B5 UD1.H9
EMI0_CA3: U1001.B6 UD1.H10
EMI0_CA4: U1001.B7 UD1.H11
EMI0_CA5: U1001.E7 UD1.J11
EMI0_CK_C: U1001.E10 UD1.J9
EMI0_CK_T: U1001.D10 UD1.J8
EMI0_CKE0: U1001.E8 UD1.J4
EMI0_CKE1: U1001.D7 UD1.J5
EMI0_CS0: U1001.D8 UD1.H4
EMI0_CS1: U1001.A7 UD1.H3
EMI0_DMI0: U1001.B4 UD1.C3
EMI0_DMI1: U1001.C8 UD1.C10
EMI0_DQ0: U1001.E5 UD1.B2
EMI0_DQ1: U1001.D5 UD1.C2
EMI0_DQ2: U1001.E6 UD1.E2
EMI0_DQ3: U1001.D6 UD1.F2
EMI0_DQ4: U1001.B3 UD1.F4
EMI0_DQ5: U1001.C5 UD1.E4
EMI0_DQ6: U1001.A5 UD1.C4
EMI0_DQ7: U1001.A3 UD1.B4
EMI0_DQ8: U1001.B11 UD1.B11
EMI0_DQ9: U1001.E11 UD1.C11
EMI0_DQ10: U1001.B10 UD1.E11
EMI0_DQ11: U1001.A9 UD1.F11
EMI0_DQ12: U1001.A11 UD1.F9
EMI0_DQ13: U1001.D9 UD1.E9
EMI0_DQ14: U1001.C9 UD1.C9
EMI0_DQ15: U1001.D11 UD1.B9
EMI0_DQS0_C: U1001.C4 UD1.E3
EMI0_DQS0_T: U1001.D4 UD1.D3
EMI0_DQS1_C: U1001.E12 UD1.E10
EMI0_DQS1_T: U1001.F12 UD1.D10
EMI1_CA0: U1001.D17 UD1.R2
EMI1_CA1: U1001.C15 UD1.P2
EMI1_CA2: U1001.B17 UD1.R9
EMI1_CA3: U1001.A17 UD1.R10
EMI1_CA4: U1001.C17 UD1.R11
EMI1_CA5: U1001.D19 UD1.P11
EMI1_CK_C: U1001.F16 UD1.P9
EMI1_CK_T: U1001.E16 UD1.P8
EMI1_CKE0: U1001.D18 UD1.P4
EMI1_CKE1: U1001.E18 UD1.P5
EMI1_CS0: U1001.E17 UD1.R4
EMI1_CS1: U1001.C16 UD1.R3
EMI1_DMI0: U1001.B18 UD1.Y3
EMI1_DMI1: U1001.B15 UD1.Y10
EMI1_DQ0: U1001.F20 UD1.AA2
EMI1_DQ1: U1001.E20 UD1.Y2
EMI1_DQ2: U1001.D20 UD1.V2
EMI1_DQ3: U1001.E19 UD1.U2
EMI1_DQ4: U1001.C20 UD1.U4
EMI1_DQ5: U1001.B19 UD1.V4
EMI1_DQ6: U1001.A19 UD1.Y4
EMI1_DQ7: U1001.C21 UD1.AA4
EMI1_DQ8: U1001.C13 UD1.AA11
EMI1_DQ9: U1001.C14 UD1.Y11
EMI1_DQ10: U1001.A13 UD1.V11
EMI1_DQ11: U1001.D15 UD1.U11
EMI1_DQ12: U1001.C12 UD1.U9
EMI1_DQ13: U1001.A15 UD1.V9
EMI1_DQ14: U1001.B14 UD1.Y9
EMI1_DQ15: U1001.D14 UD1.AA9
EMI1_DQS0_C: U1001.E21 UD1.V3
EMI1_DQS0_T: U1001.F21 UD1.W3
EMI1_DQS1_C: U1001.F13 UD1.V10
EMI1_DQS1_T: U1001.E13 UD1.W10
EMI_EXTR: R4001.2 U1001.A2
EMI_RESET_N: U1001.D22 UD1.T11
EMI_VDD2: C2029.1 C2030.1 C2031.1 C4004.1 C4005.1 C4006.1 C4007.1 C4409.1 C4410.1 C4411.1 C4412.1 C4413.1 C4421.1 C4422.1 C4423.1 C4425.1 C4426.1 C10613.1 C10614.1 PL2009.2 R90654.1 SH4401.2 U1001.G18 U1001.H11 U1001.H13 U1001.H16 UD1.A4 UD1.A9 UD1.AB4 UD1.AB9 UD1.F5 UD1.F8 UD1.G2 UD1.H1 UD1.H5 UD1.H8 UD1.H12 UD1.K1 UD1.K3 UD1.K10 UD1.K12 UD1.N1 UD1.N3 UD1.N10 UD1.N12 UD1.R1 UD1.R5 UD1.R8 UD1.R12 UD1.T2 UD1.U5 UD1.U8
EMI_VDD2_FB: SH4401.1 U2001.D11
EMI_VDD2_GND: SH4402.1 U2001.E12
EMI_VDDQ: C2032.1 C4011.1 C4012.1 C4013.1 C4014.1 C4414.1 C4415.1 C4416.1 C4417.1 C4418.1 C4424.1 C4427.1 C10619.1 R4404.2 R4405.2 R4407.2 U1001.G14 U1001.G15 U1001.H10 U1001.H12 U1001.H17 U1001.H19 U2001.P15 UD1.AA3 UD1.AA5 UD1.AA8 UD1.AA10 UD1.B3 UD1.B5 UD1.B8 UD1.B10 UD1.D1 UD1.D5 UD1.D8 UD1.D12 UD1.F3 UD1.F10 UD1.U3 UD1.U10 UD1.W1 UD1.W5 UD1.W8 UD1.W12
EMMC_VDDI: C4419.2 C4420.1 U18.C2
EN_3V3_INA_H1: Q748.3 R90751.2 R90991.1
EN_3V3_INA_H1_ODL: Q748.2 R90753.2 U124.J1
EN_LCD_BL: D2738.1(CATHODE) U1001.AD19
EN_PP1800_MIPIBRDG: R91230.1 U1001.AE25
EN_PP1800_S5_L: R91196.2 R91268.1 U6517.A7
EN_PP3300_EDP_DX: U1001.AE24 U6572.4
EN_PP3300_MIPIBRDG_DX: U1001.AD23 U6573.4
EN_PP5000_USBC: R91172.1 U6559.1
EN_SPK_AMP: R90267.1 R90268.1 U1001.AD22
EN_USBA_5V: R91206.1 U6517.A1 U6552.4
EN_USBC_CHARGE_L: R91171.1 U6559.39
EXT_PMIC_EN2: R90512.1 U2001.E5
FLASH_WP_ODL: D2705.1(CATHODE) Q750.1 R512.2 R90432.1 R90433.2 R90610.1
GP2: TP230.1 U93.7
GP3: TP231.1 U93.14
GP4: TP212.1 U93.16
GP5: TP213.1 U93.15
H1_AP_FLASH_CONTROL: D2706.2 U124.H5
H1_AP_FLASH_EN: D2706.1(CATHODE) R90423.1 R90629.1 R90984.1
H1_BATT_PRES_ODL: R91182.2 R91183.2 U124.A1
H1_BOOT0: R90448.1 U124.J3
H1_CCD_MODE_ODL: R90380.2 R91147.1 U124.B1
H1_INT_OD_L: D2736.2 R90560.2 U1001.L22
H1_KSI: R3001.1 R3002.1 U124.B4
H1_PWR_BTN_ODL: CON16.22 D2737.2 R90457.2 U124.A4
H1_RDCC1: R90386.1 R91116.1 U124.D1
H1_RDCC2: R90387.1 R91115.1 U124.D2
H1_RST_ODL: C10359.2 CON16.45 R90374.2 R90452.2 U124.G1
H1_SBU1: Q807.3 R90742.2 R91311.1
H1_SBU2: Q808.3 R90743.2 R91313.1
H1_UART_VREF: C412.1 CON16.29 Q727.3
HOMEKEY: D2707.2 U2001.G13
HP_INT_ODL: R90757.1 R90758.2 U6541.C2
HP_L: CON6201.1 ESD6206.2 R90764.2 R90777.2 R90778.2
HP_R: CON6201.2(R) ESD7509.2 R90779.2 R90780.2
HPCSN: C9048.1 U6504.C1
HPCSP: C9049.1 U6504.A1
I2C_SCL_INA: Q80.1(S) R90481.2 U124.J6
I2C_SCL_INA_SERVO: CON16.38 Q80.4 R90483.2 U6524.6 U6525.6 U6526.6 U6530.5 U6530.6 U6538.5 U6539.5 U6540.5
I2C_SDA_INA: Q81.1(S) R90482.2 U124.H6
I2C_SDA_INA_SERVO: CON16.37 Q81.4 R90484.2 U6524.7 U6525.7 U6526.5 U6526.7 U6530.7 U6538.6 U6539.6 U6540.6 U6540.7
I2S0_DI: TP9068.1 U1001.AG19 U1007.60
I2S2_BCK: U1001.Y5 U6502.C1 U6503.C1 U6504.D6
I2S2_DI: U1001.AA2 U6504.C9
I2S2_LRCK: U1001.AA3 U6502.C3 U6503.C3 U6504.D8(WCLK)
I2S2_MCK: U1001.W6 U6504.C11
I2S3_DO: U1001.AG1 U6502.B1 U6503.B1 U6504.C7
I2S3_TDM_BCK: R91152.1 U1001.AD25 U6563.10
I2S3_TDM_D0: R90818.1 U1001.AD21 U6563.8
I2S3_TDM_D1: R90813.1 U1001.AG21 U6563.7
I2S3_TDM_D2: R90814.1 U1001.AD20 U6563.6
I2S3_TDM_D3: R91151.1 U1001.Y4 U6563.5
I2S3_TDM_LRCK: R90816.1 U1001.AG23 U6563.9
I2S5_BCK: TP9071.1 U1001.W5 U1007.61
I2S5_DO: R91137.1 TP9070.1 U1001.AH1 U1007.59
I2S5_LRCK: TP9069.1 U1001.AA6 U1007.58
ISL9238C_BGATE: NC63.1 U6.32
ISL9238C_CSON: C426.2 C10496.1 R90841.2 U6.1
ISL9238C_CSOP: C426.1 C10495.1 R90840.2 U6.2
ISL9238C_LDO_5V: C439.2 R707.2 U6.18
ISL9238C_LG1: NC284.1 PQ1.8
ISL9238C_LG2: NC281.2 PQ2.8
ISL9238C_PH1: L48.1 NC283.2 PQ1.9 R90838.1
ISL9238C_PH2: L48.2 NC280.2 PQ2.9 R90839.1
ISL9238C_UG1: NC282.2 PQ1.1
ISL9238C_UG2: NC279.2 PQ2.1
ISL9238C_VDDP: C436.2 R707.1 U6.8
IT6505_CK: R90832.2 R91013.1 U5.C2
IT6505_CK_R: R91013.2 U1.80
IT6505_D0: R90822.2 U1.76 U5.D2
IT6505_D1: R90821.2 U1.75 U5.D1
IT6505_D2: R90820.2 U1.74 U5.E2
IT6505_D3: R91150.2 U1.73 U5.E1
IT6505_D4: R90826.2 U1.72 U5.F1
IT6505_D5: R90825.2 U1.71 U5.F2
IT6505_D6: R90824.2 U1.70 U5.G1
IT6505_D7: R90823.2 U1.69 U5.G2
IT6505_D8: R90830.2 U1.61 U5.H1
IT6505_D9: R90829.2 U1.60 U5.H2
IT6505_D10: R90828.2 U1.59 U5.J1
IT6505_D11: R90827.2 U1.58 U5.J2
IT6505_DE: R90831.2 U1.78 U5.C1
IT6505_HPD_L: Q718.3 U1001.W4
IT6505_HSYNC: R90834.2 U1.81 U5.B1
IT6505_I2S_BCK: R91032.1 R91152.2 U6563.14
IT6505_I2S_BCK_R: R91032.2 U1.17
IT6505_I2S_D0: R90818.2 U1.15 U6563.16
IT6505_I2S_D1: R90813.2 U1.14 U6563.17
IT6505_I2S_D2: R90814.2 U1.13 U6563.18
IT6505_I2S_D3: R91151.2 U1.12 U6563.19
IT6505_I2S_LRCK: R90816.2 U1.16 U6563.15
IT6505_INT_ODL: R90735.1 U1001.M22
IT6505_INT_ODL_R: R90735.2 R91298.2 U1.50
IT6505_RST: Q2.2 U1001.Y6
IT6505_RST_L: C46.1 Q2.3 R20.2 U1.21
IT6505_VSYNC: R90833.2 U1.82 U5.B2
JACKDET_L: R90333.1 U6504.D16
KB_INT_ODL: R91187.1 U6559.32
KSI0: CON7102.13 CON9105.13 D2722.1 U6559.18
KSI1: CON7102.24 CON9105.24 D2732.1 U6559.20
KSI2: CON7102.17 CON9105.17 D2723.1 R3001.2 R3006.1
KSI3: CON7102.16 CON9105.16 D2725.1 R3002.2 R3005.1 R90858.2
KSI4: CON7102.20 CON9105.20 D2729.1 U6559.25
KSI5: CON7102.19 CON9105.19 D2724.1 U6559.22
KSI6: CON7102.22 CON9105.22 D2730.1 U6559.26
KSI7: CON7102.23 CON9105.23 D2728.1 U6559.27
KSO0: CON7102.18 CON9105.18 D2726.1 U6559.11
KSO1: CON7102.14 CON9105.14 D2721.1 U6559.13
KSO2: CON7102.12 CON9105.12 D2720.1 U124.B8
KSO3: CON7102.11 CON9105.11 D2715.1 U6559.14
KSO4: CON7102.15 CON9105.15 D2719.1 U6559.16
KSO5: CON7102.8 CON9105.8 D2716.1 U6559.17
KSO6: CON7102.9 CON9105.9 D2717.1 U6559.15
KSO7: CON7102.21 CON9105.21 D2727.1 U6559.3
KSO8: CON7102.2 CON9105.2 D2711.1 R91145.2 U6559.2
KSO9: CON7102.3 CON9105.3 D2712.1 R91143.2 U6559.9
KSO10: CON7102.5 CON9105.5 D2718.1 U6559.8
KSO11: CON7102.4 CON9105.4 D2713.1 U6559.5
KSO12: CON7102.1 CON9105.1 D2714.1 U6559.10
KSO13: CON7102.26 CON9105.26 D2733.1 U6559.7
KSO14: CON7102.28 CON9105.28 D2734.1 U6559.6
L0DN: R192.2 U6578.F8
L0DP: R193.2 U6578.E8
L1DN: R191.2 U6578.H6
L1DP: R194.2 U6578.H7
L2DN: R187.2 U6578.D8
L2DP: R188.2 U6578.C8
L3DN: R184.2 U6578.H4
L3DP: R185.2 U6578.H5
LDO3_VOUT: PC136.1 R91275.2 R91281.1 R91305.2 R91307.2 R91308.2 R91318.1 R91330.1 U6571.11
LDO5_VOUT: PC131.1 R91314.2 R91316.2 U6570.12
LED_BLUE_ISINK: R91163.2 U6559.42
LED_GREEN_ISINK: R91162.2 U6559.41
LED_ORANGE_ISINK: R91161.2 U6559.40
LID_ACCEL_INT_L_R: J24.3 Q786.1(S) R91190.2
LID_ACCEL_INT_ODL: Q786.3 TP9183.1
LID_OPEN: D2739.1(CATHODE) R91174.2 R91181.2 R91243.1 R91252.1 R91279.1 R91302.1
MDSI_TE: TP9141.1 U1001.AG26
MECH_PWR_BTN_ODL: CON7102.25 CON9105.25 D2731.1 R90858.1 R91121.2
MIC_P: R90781.2 U6541.B4
MIC_PRESENT_L: U1001.H5 U6541.A1
MIPIBRDG_INT_ODL: R91238.2 R91280.2 U6578.B8
MIPIBRDG_PWRDN_L_1V8: R91254.2 TP9181.1 U1001.AH27 U6578.D2
MIPIBRDG_RST_L_1V8: R91253.2 TP9180.1 U1001.AF5 U6578.B7
MSDC0_CLK: U1001.D24 U6522.7
MSDC0_CLK_EMMC: U18.M6 U6522.8
MSDC0_CMD: U1001.C27 U6522.2
MSDC0_CMD_EMMC: R91008.1 U18.M5 U6522.1
MSDC0_DAT0: U1001.B26 U6522.5
MSDC0_DAT0_EMMC: R91009.1 U18.A3 U6522.4
MSDC0_DAT1: U18.A4 U1001.B27
MSDC0_DAT2: U18.A5 U1001.A26
MSDC0_DAT3: U18.B2 U1001.E24
MSDC0_DAT4: U18.B3 U1001.C26
MSDC0_DAT5: U18.B4 U1001.C25
MSDC0_DAT6: U18.B5 U1001.G23
MSDC0_DAT7: U18.B6 U1001.D26
MSDC0_DSL: U18.H5 U1001.E25
MSDC0_RSTB: U18.K5 U1001.D25
MSDC1_CLK: R90504.2 R90696.2
MSDC1_CMD: R90505.2 R90697.2
MSDC1_DAT0: R90506.2 R90699.2
MSDC1_DAT1: R90507.2 R90698.2
MSDC1_DAT2: R90508.2 R90701.2 R91066.1
MSDC1_DAT3: R90509.2 R90700.2
MT6358_HPL: R90773.2 R90777.1
MT6358_HPR: R90774.2 R90780.1
MT8183_KPCOL0: R90874.1 TP9080.1 U1001.AC4
OVCUR1_L: R91324.2 U6546.25
OVCUR4_L: R91325.2 U6546.19
PANEL_BL_PWM_3V3: J15.24 Q706.3 R90953.2
PMIC_CLK_WCN: C10374.1 R90435.2 U1001.H8
PMIC_EC_RESETB: R90581.2 R90892.1 U2001.D4
PMIC_EN_ODL: D2707.1(CATHODE) R90606.2 U6517.C1
PMIC_FORCE_RESET: R90792.1 R91185.1 U6559.38
PP1000_MIPIBRDG: C251.1 R215.2 R91236.2 R91237.2
PP1000_MIPIBRDG_A: C10685.1 C10686.2 C10687.1 R91236.1 U6578.A4 U6578.C5 U6578.C6 U6578.F5
PP1000_MIPIBRDG_D: C10682.1 C10683.2 C10684.1 R91237.1 U6578.D6 U6578.E5 U6578.E6
PP1000_MIPIBRDG_EN: U23.2 U1001.AH26
PP1800_ALW: NC295.1 Q723.2 Q724.2 R90348.1 R90527.1 R90528.1 R90639.1 R90672.2 R91228.2
PP1800_ALW_N: NC295.2 R90503.1
PP1800_ALW_P: NC296.2 R90502.1
PP1800_AP: C10550.1 C10575.1 Q3.5 Q4.5 Q705.2 Q706.2 Q734.1 Q776.5 Q777.5 Q778.5 Q779.5 R330.2 R1001.2 R1007.2 R1009.2 R1101.1 R1102.1 R1103.2 R1104.2 R1105.1 R1106.1 R1107.1 R1108.1 R1109.1 R1110.1 R1111.1 R1112.1 R1113.1 R1114.1 R1501.1 R1502.1 R90163.2 R90461.2 R90462.2 R90463.1 R90471.1 R90560.1 R90561.1 R90562.2 R90563.2 R90587.2 R90625.2 R90626.2 R90656.1 R90659.2 R90725.2 R90727.2 R90729.2 R91008.2 R91009.2 R91130.1 R91131.1 R91199.1 R91212.1 R91238.1 SH1701.1 SH2101.2 U5.A1 U5.C4 U5.H4 U5.K1 U6563.1 U6563.2
PP1800_EC: C10354.1 C10355.1 C10356.1 C10357.1 C10358.1 C10469.2 NC252.1 Q8.2(S) Q739.5 Q750.2(S) Q757.2 Q759.2 Q783.2 Q784.2 Q787.2 Q788.2 Q793.2 Q794.2 R338.1 R619.1 R90366.2 R90368.1 R90373.1 R90440.2 R90451.1 R90460.1 R90472.2 R90521.1 R90522.1 R90523.1 R90524.1 R90605.1 R90982.1 R91196.1 R91248.1 R91249.1 R91279.2 U6517.D2 U6517.E4 U6517.E5 U6547.8
PP1800_EC_N: NC252.2 R90543.1
PP1800_EC_P: NC251.2 R90544.1
PP1800_EMMC: C4404.2 C4405.2 C4406.2 R90163.1 U18.C6 U18.M4 U18.N4 U18.P3 U18.P5
PP1800_H1: C10370.1 C10372.1 C10373.1 NC248.1 Q80.2 Q81.2 R323.1 R90364.2 R90407.1 R90410.2 R90433.1 R90481.1 R90482.1 R90973.2 R90975.1 R90976.1 R91277.1 U124.E9 U124.J4
PP1800_H1_N: NC248.2 R90541.1
PP1800_H1_P: NC247.2 R90542.1
PP1800_H1_PG: Q802.3 R90452.1 R90628.2
PP1800_IT6505_A: FB1.1 FB2.1 FB3.1 FB4.1 FB5.1 R90354.2
PP1800_IT6505_D: C19.1 C20.1 C21.1 C22.1 C23.1 C24.1 R90352.2 U1.6 U1.19 U1.20 U1.51 U1.55 U1.63 U1.79 U1.85
PP1800_IT6505_ENABLE: R90941.1 U1001.Y7
PP1800_LDO: NC247.1 NC251.1 PC139.1 PU1.5(VOUT) R90364.1 R90366.1
PP1800_LPDDR: C1005.2 C1006.1 C4407.1 C4408.1 R90638.1 U1001.G9 UD1.F1 UD1.F12 UD1.G4 UD1.G9 UD1.T4 UD1.T9 UD1.U1 UD1.U12
PP1800_MIPIBRDG: R91229.1 R91234.2 R91235.2 R91260.2
PP1800_MIPIBRDG_A: C10679.1 C10680.2 C10681.1 R91234.1 U6578.E3 U6578.F3
PP1800_MIPIBRDG_D: C10676.1 C10677.2 C10678.1 Q799.5 Q800.5 R91233.2 R91235.1 R91240.1 R91241.1 R91253.1 R91254.1 U6578.F4
PP1800_S3: NC274.1 Q767.1 Q768.1 Q799.2 Q800.2 R90519.2 R90535.1 R90562.1 R90629.2 R90638.2 R91139.1
PP1800_SENSOR: C10460.1 C10641.1 J24.1 Q725.2 Q726.2 Q786.2 R7701.2 R90264.2 R90417.1 R90418.2 R90514.1 R90515.1 R90535.2 R90860.2 R90871.2 R90872.2 R90995.2 R91190.1 U6575.B2(VDDIO) U6575.E5
PP1800_SPI_FLASH: C434.2 CON16.6 R334.1 R350.2 R90640.2 R90985.2 U49.8(VCC)
PP1800_WLAN: C10424.1 C10482.1 NC275.1 R91066.2 R91134.2 R91137.2 R91139.2 U1007.42
PP1800_WLAN_N: NC275.2 R90718.2
PP1800_WLAN_P: NC274.2 R90717.2
PP3000_EMMC: C10485.1 R90164.2 U2001.R11
PP3000_EMMC_R: C4401.2 C4402.2 C4403.1 R90164.1 U18.E6 U18.F5 U18.J10 U18.K9
PP3300_ALW: C175.1 C748.1 C749.1 C10412.2 C10604.1 C10642.1 C10664.1 C10688.1 C10717.2 NC249.1 NC293.1 Q727.2 Q785.2 R1.2 R218.2 R277.1 R420.1 R941.1 R942.1 R90365.1 R90367.1 R90465.1 R90479.1 R90529.1 R90678.2 R90737.1 R90751.1 R90753.1 R90852.1 R90855.2 R90861.1 R90912.1 R90992.1 R91051.1 R91052.1 R91111.1 R91210.1 R91211.1 R91246.1 R91247.1 R91271.2 R91302.2 R91310.1 R91317.1 R91326.1 U93.30(VCC) U6533.A3(VDD) U6555.12(VDD) U6573.5 U6576.5 U6580.3(VDD) U6582.C2(VPWR) U6582.C3
PP3300_ALW_N: NC293.2 R90488.1
PP3300_ALW_P: NC294.2 R90489.1
PP3300_ALW_PG: PP3300_ALW_PG.1 Q804.2 Q806.1 R91305.1 U6571.7
PP3300_CAM: C10636.1 J15.13 J15.14 R91125.2
PP3300_CTP: C9063.2 J15.35 NC267.2 Q776.2 Q777.2 Q778.2 Q779.2 R90475.2 R91126.1 R91127.1 R91129.1 R91132.1
PP3300_CTP_N: NC267.1 R90490.1
PP3300_CTP_P: NC266.1 R90491.1
PP3300_EC: C10350.1 R521.2 R90367.2 R90371.2 R91304.2
PP3300_EDP_DX: C10525.2 J15.27 J15.28 J15.29 NC268.2 R90518.2
PP3300_EDP_DX_N: NC268.1 R90540.1
PP3300_EDP_DX_P: NC269.1 R90539.1
PP3300_EDP_DX_R: C431.1 NC269.2 R252.1 R90518.1 R90952.1 R90953.1 U6572.1(VOUT)
PP3300_H1: C10365.1 C10367.1 C10368.1 NC250.1 Q717.2(S) Q739.2 Q780.2 R90365.2 R90374.1 R90376.2 R90377.1 R90380.1 R90455.1 R90457.1 R90630.1 R90937.2 R91088.2 R91182.1 R91186.2 R91278.2 R91303.2 R91312.2 R91315.2 U124.A7 U124.B2 U124.H1
PP3300_H1_EC: PC138.1 PC140.1 PU1.1 Q804.1(S) Q805.1(S) R91271.1 R91303.1 R91304.1 R91306.2 R91307.1 R91309.2
PP3300_H1_N: NC250.2 R90498.1
PP3300_H1_P: NC249.2 R90499.1
PP3300_HUB: C10455.1 C10456.1 C10457.1 C10458.1 C10623.2 C10624.1 R91098.2 R91099.1 R91100.2 R91225.1 R91324.1 U6546.5 U6546.9 U6546.14 U6546.21 U6546.27 U6546.28
PP3300_INA: C10382.1 C10383.1 C10384.1 C10399.1 C10431.1 C10432.1 C10433.1 Q80.5 Q81.5 R90483.1 R90484.1 R90988.2 R90993.2 U6524.4 U6524.16 U6525.4 U6525.5 U6525.16 U6526.4 U6526.16 U6530.4 U6530.16 U6538.4(VS) U6538.8 U6539.4(VS) U6539.7 U6539.8 U6540.4(VS) U6540.8
PP3300_KBC: C10502.2 C10503.2 C10504.2 R90852.2 R91145.1 U6559.4 U6559.24 U6559.37(VSTBY_3)
PP3300_MIPIBRDG_DX: C10673.1 C10674.2 C10675.1 R252.2 R90815.2 R91232.2 R91261.2 U6578.C4
PP3300_S3: C444.1 C9061.2 C10621.1 J20.6 NC266.2 NC272.1 R90474.2 R90475.1 R90695.1 R91100.1 R91125.1 R91136.1 U6574.1(VDD)
PP3300_SERVO_INA: R476.1 R90986.1 R90987.1
PP3300_THRM: R91317.2 R91318.2 R91320.1
PP3300_THRM_R: C10711.1 R91320.2 U6581.5(VCC)
PP3300_TPAD: C368.2 CON12.6 Q730.1 Q731.1 Q732.1 R9499.1 R90695.2 R91112.1 R91113.1
PP3300_WLAN: C10420.1 C10421.1 C10422.1 C10423.1 NC273.1 R90624.1 R90627.1 R90843.2 R91136.2 U1007.4 U1007.5 U1007.72 U1007.73
PP3300_WLAN_N: NC273.2 R90716.2
PP3300_WLAN_P: NC272.2 R90715.2
PP5000_ALW: C10413.1 C10571.2 C10622.2 NC256.2 R90530.1 R90537.1 R90558.1 R90668.2 R90708.1 R90870.2 R90876.2 R91327.1 SH2302.1 U6533.B1 U6552.5 U6577.A1 U6577.B1
PP5000_PMIC: NC255.2 NC271.1 R2001.1 R90558.2 R90641.1 R90642.1 R90643.1 R90644.1 R90645.1 R90646.1 R90647.1 R90648.1 R90649.1 R90650.1 R90651.1 R90652.1 R90904.1
PP5000_PMIC_N: NC255.1 R90497.1
PP5000_PMIC_P: NC256.1 R90496.1
PP5000_SMPS: C2001.1 R2001.2 U2001.E2
PP5000_USB_A0_VBUS: C487.1 J17.1 J17.2 J17.3 J17.4 J17.5 J17.6 U6552.1(VOUT)
PP5000_VCORE: C2009.1 R90643.2 U2001.A15 U2001.B15
PP5000_VDRAM1: C2028.1 NC270.1 R90649.2 U2001.J16
PP5000_VDRAM1_N: NC270.2 R90720.2
PP5000_VDRAM1_P: NC271.2 R90719.2
PP5000_VGPU: C2025.1 R90648.2 U2001.A11 U2001.B11
PP5000_VMODEM: C2013.1 R90644.2 U2001.F14
PP5000_VPA: C2016.1 R90645.2 U2001.A5
PP5000_VPROC11: C2004.1 R90641.2 U2001.A6 U2001.B6
PP5000_VPROC12: C2007.1 R90642.2 U2001.A10 U2001.B10
PP5000_VS1: C2023.1 R90646.2 U2001.B1 U2001.C1
PP5000_VS2: C2024.1 R90647.2 U2001.K15 U2001.K16
PPVAR_BATT: C375.1 ESD7511.1(CATHODE) NC288.2 R90819.1 R90842.2 U45.5
PPVAR_BUCKBOOST: C437.2 C10710.2 R90835.2 U6.17
PPVAR_PWR_IN: C10566.1 Q789.5 R654.1 R2302.1 R2304.1 R90836.1 U6558.A1 U6558.B1 U6558.C1 U6558.D1
PPVAR_PWR_IN_BB: C438.1 C457.1 C493.1 C503.1 C504.1 PQ1.2 R654.2 R90837.1
PPVAR_SYS: C10715.1 D761.1 NC291.1 NC303.1 R391.1 R90662.1 R90669.1 R90674.1 R91194.2 R91200.2
PPVAR_SYS_BL_N: NC302.2 R443.1
PPVAR_SYS_BL_P: NC303.2 R442.1
PPVAR_SYS_N: NC291.2 R90500.1
PPVAR_SYS_P: NC292.2 R90501.1
PPVAR_SYS_R: C491.1 C10499.1 C10500.1 C10501.1 C10508.1 C10712.1 C10713.1 C10714.1 NC292.1 PQ2.2 R612.1 R90840.1 R91200.1
PPVAR_USB_C0_VBUS: C10570.1 D761.2 NC245.2 Q801.5 R503.1 R90538.2 R91028.1 R91226.1 R91295.1 U6533.A2 U6558.B2 U6558.C2 U6558.D2 U6558.E1 U6558.E2 U6577.A3 U6577.B3(VOUT#2)
PPVAR_USB_C0_VBUS_N: NC245.1 R90492.1
PPVAR_USB_C0_VBUS_P: NC246.1 R90493.1
PPVAR_USB_C0_VBUS_R: Q789.1 Q789.2 Q789.3(S3) Q801.1 Q801.2 Q801.3(S3) R91295.2 U6.16
PPVAR_VSYS_R: C492.2 R612.2 R90841.1 U45.1 U45.2 U45.3(S3)
PROTO_SEL: R90860.1 U6575.A1
PWRAP_SPI0_CK: U1001.P23 U2001.F11
PWRAP_SPI0_CSN: R1001.1 R1004.2 U1001.N23 U2001.F13
PWRAP_SPI0_MI: U1001.P24 U2001.G10
PWRAP_SPI0_MO: U1001.P25 U2001.G11
PWRKEY: R90606.1 U2001.D2
RAM_ID: C10439.1 R90727.1 R90728.1 U1001.AE18
REFP: C1009.2 U1001.AJ18
RING2: R90334.1 U6504.C13
RING2_SENSE: C9053.1 R90765.1 U6504.B4
RTC32K_CK: U1001.K26 U2001.F10
SCP_VREQ_VAO: U1001.N25 U2001.H13
SDIO_INT_ODL: R90625.1 U1001.J4 U1007.46
SERVO_EC_BOOT0_ODL: CON16.41 Q8.1 R90451.2
SERVO_JTCK: CON16.21 R313.2 R90340.2 R90962.2
SERVO_JTDI: CON16.24 R90342.2
SERVO_JTDO: CON16.25 R314.2 R90343.2 R90963.2
SERVO_JTMS: CON16.23 R90341.2
SERVO_JTRST: CON16.27 R90591.2
SERVO_SYS_RST_ODL: CON16.39 R90683.2
SLEEVE: R90335.1 U6504.A11
SLEEVE_SENSE: C9054.1 R91140.1 U6504.B6
SOC_I2C0_1V8_SCL: Q777.4 R1102.2 R90612.1 U1001.AB6
SOC_I2C0_1V8_SDA: Q776.4 R1101.2 R90614.1 U1001.AC5
SOC_I2C2_1V8_SCL: Q768.2(S) R1106.2 U1001.AB2
SOC_I2C2_1V8_SDA: Q767.2(S) R1105.2 U1001.AB1
SOC_I2C3_1V8_SCL: R1108.2 R90783.1 U1001.AF22
SOC_I2C3_1V8_SDA: R1107.2 R90784.1 U1001.AG22
SOC_I2C4_1V8_SCL: Q800.1(S) R1110.2 R91255.1 U1001.Y2
SOC_I2C4_1V8_SDA: Q799.1(S) R1109.2 R91256.1 U1001.W2
SOC_I2C5_1V8_SCL: R1111.2 U1001.AH24 U6504.D12 U6541.C3
SOC_I2C5_1V8_SDA: R1112.2 U1001.AH25 U6504.D14 U6541.B3
SOC_I2C6_1V8_SCL: I2C6_SCL_MTK.1 R1114.2 U1001.N26
SOC_I2C6_1V8_SDA: I2C6_SDA_MTK.1 R1113.2 U1001.P26
SPI0_CLK: R91082.1 U1001.AF3
SPI0_CSB: R91081.1 U1001.AG3
SPI0_MI: R91079.1 U1001.AJ2
SPI0_MO: R91080.1 U1001.AH2
SPI2_CLK: R90336.1 U1001.AG2
SPI2_CSB: R90337.1 U1001.AB5
SPI2_MI: R90339.1 U1001.AE3
SPI2_MO: R90338.1 U1001.AB4
SPI_AP_EC_CLK: R90336.2 U6517.A5
SPI_AP_EC_CS_L: R90337.2 U6517.A6
SPI_AP_EC_MISO: R90339.2 U6517.A4
SPI_AP_EC_MOSI: R90338.2 U6517.C4
SPK_L_N: C9018.2 CON9104.3 ESD7505.1 R90917.2 TP9075.1
SPK_L_P: C9019.2 CON9104.4 ESD7506.1 R90916.2 TP9074.1
SPK_R_N: C6324.2 CON9104.1 ESD6309.1 R90915.2 TP9073.1
SPK_R_P: C6329.2 CON9104.2 ESD6310.1 R90914.2 TP9072.1
SRCLKENA0: R90525.1 U1001.R23 U2001.L7
SRCLKENA1: U1001.R24 U2001.J7
SYS_RST_ODL: D2708.1(CATHODE) R90455.2 R90913.1 R90969.2 U124.A2
SYS_RST_ODL_R: R90969.1 U6548.8
SYSRSTB: D2708.2 R90581.1 R90582.2 U1001.K23
TABLET_MODE_L: R9572.1 R91173.2 R91244.2
THRM_SET: R91321.1 R91322.1 U6581.1
TOUCH_INT_ODL: Q778.4 R91130.2 R91135.1 U1001.P22
TOUCH_INT_ODL_R: J15.38 Q778.1(S) R91129.2 R91135.2
TOUCH_RST_3V3_ODL: J15.39 Q779.1(S) R91132.2 R91133.2
TOUCH_RST_L_1V8: Q779.4 R91131.2 R91133.1 U1001.T23
TPAD_INT_N: CON12.2 Q732.2(S) R91113.2
TPAD_SCL: CON12.4 Q730.2(S) R9499.2
TPAD_SDA: CON12.5 Q731.2(S) R91112.2
TRACKPAD_BTN_L: CON12.1 TP9142.1
TRACKPAD_INT_1V8_ODL: Q734.2(S) R91212.2 U1001.AE1
TS3A227E_POWER: C10442.1 C10443.1 R90737.2 U6541.A3(VDD)
TX0N: C10704.1 U1.35
TX0P: C10703.1 U1.36
TX1N: C10700.1 U1.32
TX1P: C10699.1 U1.33
TX2N: C10702.1 U1.29
TX2P: C10701.1 U1.30
TX3N: C10706.1 U1.26
TX3P: C10705.1 U1.27
TX_AVCC: C25.1 C26.1 C27.1 C28.1 C29.1 FB1.2 R4.2 U1.25 U1.28 U1.31 U1.34 U1.37
TX_OVDD: C1.1 C2.1 C3.1 C4.1 C6.1 C7.1 C8.1 C10.1 C9016.1 C9017.1 C10551.1 C10576.1 Q3.2 Q4.2 R20.1 R90154.2 R90155.2 R90580.2 R91170.2 R91207.2 R91298.1 U1.4 U1.18 U1.52 U1.64 U1.83 U5.C3 U5.H3(VCCB2) U6563.23(VCCB2) U6563.24
TX_PVCC0: C15.1 C16.1 FB2.2 U1.41
TX_PVCC1: C13.1 C14.1 FB3.2 U1.39
TX_PVCC2: C17.1 C18.1 FB4.2 U1.40
TX_XVCC18: C11.1 C12.1 FB5.2 U1.42(XVCC18)
TXAUXN: C9036.1 U1.23
TXAUXP: C9035.1 U1.24
UART_AP_TX_DBG_RX: R332.1 R90389.1 U1001.AD1
UART_BT_WAKE_ODL: R90626.1 U1001.J5 U1007.53
UART_DBG_RXD_WLAN: R91134.1 U1007.29
UART_DBG_TX_AP_RX: R331.2 R90388.1 U1001.AD2
UART_DBG_TX_EC_RX: R90439.2 R90441.2 U6517.C6
UART_DBG_TXD_WLAN: R90843.1 U1007.30
UART_EC_TX_DBG_RX: R90438.1 R90442.1 U6517.C7
UART_H1_TX_SERVO_RX: R314.1 U124.B9
UART_SCP_TX_SERVO_RX: R90963.1 U1001.K3
UART_SERVO_TX_H1_RX: R313.1 R90407.2 U124.H7
UART_SERVO_TX_SCP_RX: R90962.1 U1001.L3
USB2_A0_N: J17.13 U6546.6
USB2_A0_P: J17.12 U6546.7
USB2_DM: R91300.1 U1001.F26
USB2_DM_R: R91300.2 U6546.1
USB2_DP: R91301.1 U1001.G26
USB2_DP_R: R91301.2 U6546.2
USB2_HUB_P1_N: U6546.3 U6555.2
USB2_HUB_P1_P: U6546.4 U6555.1
USB2_HUB_P3_N: J15.10 U6546.12
USB2_HUB_P3_P: J15.11 U6546.13
USB2_HUB_P4_N: L12.3 U6546.15
USB2_HUB_P4_P: L12.2 U6546.16
USB2_WFC_N: J20.3 L12.4
USB2_WFC_P: J20.2 L12.1
USB_A0_OC_ODL: R91225.2 R91331.1 U6546.24
USB_A0_OC_ODL_R: R91331.2 U6552.3
USB_C0_CC1: C10448.2 CON7101.A5 D2743.1 Q762.3 R91328.2 U6582.A1
USB_C0_CC1_U: R91328.1 U6533.C1 U6582.B1
USB_C0_CC2: C10449.2 CON7101.B5 D2742.1 Q763.3 R91329.2 U6582.A3
USB_C0_CC2_U: R91329.1 U6533.A1 U6582.B3
USB_C0_DISCHARGE: Q790.2 R91245.2 U6517.D3
USB_C0_HPD_OD: Q718.2 R10.2 R90580.1 U6517.D1
USB_C0_PD_INT_ODL: R90605.2 R90633.1 U6517.G5
USB_C0_RX1_C_N: C10653.1 R91284.2 U93.32
USB_C0_RX1_C_P: C10652.1 R91283.2 U93.31
USB_C0_RX1_N: C10653.2 CON7101.B10 R91158.2 U3.4 U3.7
USB_C0_RX1_P: C10652.2 CON7101.B11 R91159.2 U3.5 U3.6
USB_C0_RX2_C_N: C10708.1 R91290.2 U93.6
USB_C0_RX2_C_P: C10707.1 R91289.2 U93.5
USB_C0_RX2_N: C10708.2 CON7101.A10 R91156.2 U2.1 U2.10(NC#4)
USB_C0_RX2_P: C10707.2 CON7101.A11 R91157.2 U2.2 U2.9
USB_C0_SBU1: CON7101.A8 D2740.1 R90742.1 R90744.2 R90810.1
USB_C0_SBU1_MUX: Q781.1(S) R91292.1
USB_C0_SBU1_MUX_R: R91292.2 U93.10
USB_C0_SBU2: CON7101.B8 D1.1 R90743.1 R90745.2 R90811.1
USB_C0_SBU2_MUX: Q782.1(S) R91291.1
USB_C0_SBU2_MUX_R: R91291.2 U93.11
USB_C0_TX1_C_N: C10649.1 R91286.2 U93.2
USB_C0_TX1_C_P: C10656.1 R91285.2 U93.1
USB_C0_TX1_N: C10649.2 CON7101.A3 U3.1 U3.10(NC#4)
USB_C0_TX1_P: C10656.2 CON7101.A2 U3.2 U3.9
USB_C0_TX2_C_N: C10651.1 R91288.2 U93.4
USB_C0_TX2_C_P: C10650.1 R91287.2 U93.3
USB_C0_TX2_N: C10651.2 CON7101.B3 U2.4 U2.7
USB_C0_TX2_P: C10650.2 CON7101.B2 U2.5 U2.6
USB_C0_USB2_L_N: CON7101.A7 CON7101.B7 D2741.2(K2) EMI7101.2
USB_C0_USB2_L_P: CON7101.A6 CON7101.B6 D2741.1 EMI7101.3(O2)
USB_C0_USB2_N: EMI7101.1 U6555.7
USB_C0_USB2_P: EMI7101.4 U6555.8
USB_HUB_RESET_L: C10454.2 R91099.2 U6546.17
USBA_POWER_EN: R91206.2 U1001.AJ25
UVLO_VTH: R2204.2 U2001.M13
VA12_PMU: C1001.2 C1010.2 C2148.1 C4202.2 C5001.2 C6702.1 C6901.1 C7101.2 U1001.AA13 U1001.AH20 U1001.C2 U1001.C23 U1001.H22 U1001.V23 U1001.W3 U2001.N16
VAUD28_PMU: C10484.1 R90658.2 U2001.R5
VAUX18_PMU: C2108.1 L6904.2 U2001.M6
VBIF28_PMU: C2106.1 R2301.1 U2001.M9
VCAMA2_PMU: C2105.1 U2001.N10
VCAMA_PMU: C10483.1 U2001.M10
VCAMD_PMU: C2142.1 U2001.M15
VCAMIO_PMU: C2133.1 R91260.1 U2001.E6
VCDT: R2302.2 R2303.1 U2001.K12
VCN18_PMU: C2134.1 U2001.F6
VCORE: PL2003.1 U2001.A14 U2001.B14
VDRAM1: PL2009.1 U2001.J15
VEFUSE_PMU: C2135.1 C10488.1 U1001.F24 U2001.E3
VFE28_PMU: C2112.1 U2001.R7
VGPU: PL2008.1 U2001.A12 U2001.B12
VIO18_MT6358: C2132.1 R90520.1 R90563.1 R90995.1 R91091.2 R91299.1 U2001.F3
VIO18_PMU_AP: C1701.2 C1702.2 C1703.2 C1704.2 C1706.2 C1707.2 C1709.2 C4101.2 C4301.2 C7405.2 C7407.2 R90622.2 SH1701.2 U1001.AA1 U1001.AA27 U1001.AE27 U1001.AG27 U1001.AJ21 U1001.E27 U1001.L2 U1001.M27 U1001.W27
VMC_PMU: C2124.1 U2001.R9
VMCH_PMU: C10552.1 R91261.1 U2001.R10
VOLDN_BTN_ODL: J17.7 R91214.2 R91217.2
VOLUP_BTN_ODL: J17.9 R91213.2 R91218.2
VPROC11: PL2001.1 U2001.A7 U2001.B7
VPROC12: PL2002.1 U2001.A9 U2001.B9
VREF: C2138.1 U2001.M12
VRF12_PMU: C2149.1 U2001.N15 U2001.P16
VRF18_PMU: C2136.1 U2001.F5
VRTC28: C8201.1 R8201.1 U2001.M8(VRTC28)
VS1: PL2006.1 U2001.A2 U2001.B2
VS1_LDO1: C2113.1 C2116.1 C2130.1 R90653.2 U2001.E4 U2001.E7
VS1_PMU: PL2006.2 R90653.1
VS2: PL2007.1 U2001.L15 U2001.L16
VS2_PMU: PL2007.2 R90655.1
VS2_PMU_R: C2129.1 R90655.2 U2001.D16 U2001.M14 U2001.N14 U2001.P13
VSIM1_PMU: C2121.1 C7406.2 U1001.AF25 U2001.N7
VSIM2_PMU: C2120.1 R91207.1 U2001.P10 U6576.4
VSYSSNS: C10628.1 R90904.2 U2001.M11
VUSB_PMU: C7104.1 C10486.1 U1001.F25 U2001.N8
VXO22_PMU: C2111.1 U2001.P6
WIFI_EN_1V8: Q723.1(S) R90897.2 U1001.H6
WIFI_EN_3V3: C10638.1 Q723.3 R90624.2 R90898.2 U1007.45(WL_EN)
WLAN_RF_KILL_L: R91141.2 U1001.AD4
XO_CEL: C10689.1 R91257.1 U2001.R3
XO_SOC: R8001.1 U2001.P4
XO_WCN: R90435.1 U2001.P3
XTAL1: C10605.1 U2001.N1 X8101.1
XTAL2: C10606.1 U2001.P1 X8101.3
ZQ0_A: R4404.1 UD1.A5
ZQ1_A: R4405.1 UD1.A8
ZQ2_A: R4407.1 UD1.G11
N39948003: NC282.1 U6.11
N39948199: C440.2 NC280.1 U6.6
N39948619: NC279.1 U6.5
N39948871: NC281.1 U6.7
N39949141: R709.2 U6.24
N39949154: C488.1 NC283.1 U6.10
N39970803: C488.2 R720.1
N39971047: R720.2 U6.12
N39984522: R721.2 U6.4
N39984767: C440.1 R721.1
N45881871: R90876.1 U2001.D15
N45901165: C2125.1 U2001.N9 VIO28_PMU.1
N46231484: C2101.1 R90650.2 U2001.P7
N46231535: C2103.1 R90652.2 U2001.N11
N46231597: C2102.1 R90651.2 U2001.P9
N46233111: C2117.1 R90654.2 U2001.R15
N46264414: C2139.1 C2140.1 R90656.2 R91299.2 U2001.L9
N46324535: U2001.F15 U2001.F16 VMODEM.1
N46439912: U2001.P8 VLDO28_PMU.1
N51761964: R90877.2 U1001.AA15 U1001.AA19 U1001.AB16 U1001.AB20 U1001.AC15 U1001.AC19 U1001.AD16
N51955732: C4302.1 R90622.1 U1001.AB27
N52164405: C6106.1 U2001.G2
N52164407: C6106.2 U2001.F2
N52164418: C6104.2 C6105.1 SH6102.2 U2001.H1
N52164422: C6105.2 U2001.F1
N52164426: C6104.1 R90659.1 U2001.H2
N52164464: C6101.1 R90658.1 U2001.J3
N52167840: C8202.1 R8201.2
N52329114: I2C1_SCL_MTK.1 R1104.1 U1001.AE4
N52329116: I2C1_SDA_MTK.1 R1103.1 U1001.AF4
N53426645: U2001.R6 VCN28_PMU.1
N53427825: U2001.P11 VIBR_PMU.1
N53513826: U2001.N12 VCN33_PMU.1
N54517064: R90914.1 U6502.A3
N54517066: R90915.1 U6502.B3
N54517443: R90916.1 U6503.A3
N54517445: R90917.1 U6503.B3
N54601609: C9067.1 R90352.1 R90354.1 U6514.A1(VOUT)
N54695190: EXT_PMIC_EN1.1 U2001.D3
N54973657: R90373.2 U6517.B2
N54973804: R90554.1 U6517.E2
N54973834: R90368.2 U6517.E6
N54973848: R90371.1 U6517.H1
N54975848: R90504.1 U1007.52
N54975861: R90505.1 U1007.51
N54975866: R90506.1 U1007.50
N54975879: R90507.1 U1007.49
N54975900: R90508.1 U1007.48
N54975905: R90509.1 U1007.47
N54976308: TP9060.1 U1007.64
N54976310: TP9061.1 U1007.65
N54990858: CON16.33 R90438.2
N54990873: CON16.32 R90439.1
N54990958: CON16.35 R476.2
N54990985: CON16.16 R331.1
N54991151: CON16.40 R512.1
N54991199: CON16.14 R90682.1
N55124912: R90628.1 U6517.G6
N55125049: R90892.2 U6517.C3
N55392694: R90389.2 U124.E8
N55392696: R90388.2 U124.G8
N55392702: D2736.1(CATHODE) U124.F8
N55392761: R90441.1 U124.H4
N55392763: R90442.2 U124.J2
N55392804: R90385.2 U124.E1
N55392806: R90384.2 U124.F1
N55392842: R90383.2 U124.E2
N55392848: R90382.2 U124.F2
N55392869: R90680.1 R90937.1 U124.C1
N55392976: R90681.1 U124.B3
N55392985: R90432.2 U124.B6
N55392987: R90386.2 R91188.1 U12.1 U12.2
N55392989: R90387.2 R91189.1 U12.6 U12.7
N55504545: D761.3(COMMON ANODE) R90835.1
N55506085: C10493.1 R90838.2
N55506209: C10494.1 R90839.2
N55549814: C10505.1 U6559.21
N55550359: R90853.1 U6559.29
N55550482: R90854.1 R90855.1 U6559.28
N55694571: R90845.1 R90899.2 U1007.27
N55757845: R90688.1 U6517.G3
N56177052: D2705.2 R350.1 R90611.1 U49.3
N56177260: R90425.2 R90428.2 R90640.1 U49.1
N56177291: R90424.2 R90429.2 U49.2
N56177312: R90426.1 R90431.1 U49.6
N56177318: R90427.1 R90430.1 U49.5
N56253380: C9047.1 U6504.D2
N56253382: C9047.2 U6504.C3
N56253413: C9052.1 U6504.B8
N56318932: Q807.2(S) R90382.1 R90385.1 R91311.2
N56318941: Q808.2(S) R90383.1 R90384.1 R91313.2
N56324356: R90757.2 U2001.J4
N56451042: RTC32K_2V8.1 U2001.M7
N56454933: R91141.1 U1007.28
N56604556: R90844.2 U1007.13
N56886955: R91179.2 U6517.D8
N57277369: R90893.1 U6517.H4
N57503421: CON16.43 R90874.2
N57744014: C333.2 R443.2 U6525.11
N57744016: C333.1 R442.2 U6525.12
N57744064: C10385.2 R90488.2 U6525.14
N57744066: C10385.1 R90489.2 U6525.15
N57744104: C10386.2 R90490.2 U6525.1
N57744106: C10386.1 R90491.2 U6525.2
N57744144: C10387.2 R90492.2 U6524.11
N57744146: C10387.1 R90493.2 U6524.12
N57744176: C10388.2 R90494.2 U6524.14
N57744178: C10388.1 R90495.2 U6524.15
N57744224: C10389.2 R90497.2 U6524.1
N57744226: C10389.1 R90496.2 U6524.2
N57744256: C10390.2 R90498.2 U6526.11
N57744258: C10390.1 R90499.2 U6526.12
N57744304: C10391.2 R90500.2 U6526.14
N57744306: C10391.1 R90501.2 U6526.15
N57744336: C10392.2 R90503.2 U6526.1
N57744338: C10392.1 R90502.2 U6526.2
N57744932: C10400.2 R90540.2 U6530.11
N57744934: C10400.1 R90539.2 U6530.12
N57744959: C10401.2 R90541.2 U6530.14
N57744961: C10401.1 R90542.2 U6530.15
N57744999: C10402.2 R90543.2 U6530.1
N57745009: C10402.1 R90544.2 U6530.2
N57745825: C10434.1 R90717.1 U6539.1
N57745829: C10434.2 R90718.1 U6539.2
N57745845: C10435.1 R90715.1 U6538.1
N57745857: C10435.2 R90716.1 U6538.2
N57745883: C10436.1 R90719.1 U6540.1
N57745895: C10436.2 R90720.1 U6540.2
N57747685: Q80.3 Q80.6
N57747756: Q81.3 Q81.6
N57851870: C10644.2 R90912.2 U6548.1(VDD)
N57879546: C9066.2 R90639.2 U6514.A2
N57881020: R90941.2 U6514.B2
N57966251: C8101.2 SH8101.1 U2001.M4
N57966255: C8101.1 L6904.1 U2001.M3
N58126390: CON16.17 R332.2
N58126933: Q727.1(S) R323.2 R90587.1
N58199130: CHG_QONB_MTK.1 U6548.7
N58200688: BATT_DISABLE_ODL_MTK.1 U6548.6
N58463847: C10539.2 R90992.2 U6553.5
N58463851: C10540.1 R90993.1 U6553.1(VOUT)
N58463944: C10535.2 R90986.2 U6554.5
N58463958: C10538.1 R90988.1 U6554.1(VOUT)
N58463974: R90987.2 U6554.4
N58586333: R90758.1 U1001.R22
N59253824: R90991.2 U6553.4
N59275044: C10378.1 R90465.2 U6522.14(VDD)
N59275078: R91031.2 U6522.15
N60013740: C45.1 R17.2 U1.44 Y1.3
N60013744: C44.1 R17.1 U1.43 Y1.1
N60013813: TP9044.1 U1.11
N60013922: R10.1 U1.22
N60013924: R4.1 U1.38
N60014085: R3.1 U1.56
N60014313: R12.2 U1.48
N60014315: R13.2 U1.49
N60014348: R15.2 U1.45
N60384112: C10620.1 R91088.1 R91314.1 U12.8
N60385347: R91087.1 R91188.2 U12.3
N60385350: Q762.2(S) R91087.2 R91092.2 R91116.2
N60385391: R91089.1 R91189.2 U12.5(PLUS INPUT)
N60385409: Q763.2(S) R91089.2 R91093.2 R91115.2
N60471943: R91094.2 U6574.4
N60472929: Q762.1 Q763.1 R91315.1 R91316.1
N60563932: C10461.1 R90746.1 U6546.11(X2) Y2.3
N60563934: C10462.1 R90746.2 U6546.10 Y2.1
N60565652: SH8102.1 U2001.M2
N60574427: C10533.2 R338.2 U6531.A2
N60574429: R90984.2 U6531.B2
N60574431: C10534.1 R90985.1 U6531.A1(VOUT)
N60577846: Q730.3 Q768.3
N60577867: Q731.3 Q767.3
N60586308: R91118.2 U6555.4
N60586345: R91117.2 U6555.3
N60586415: R90462.1 R91217.1 U1001.AE2
N60586427: R90461.1 R91218.1 U1001.AF2
N60586444: R91280.1 U1001.AC3
N60699731: R91098.1 U6546.22
N60699944: R91097.2 U6546.23
N60700030: R90741.1 U6546.8
N60700076: HUB_TEST.1 U6546.18
N60700101: HUB_SDA.1 U6546.26
N60701330: C10639.2 R90815.1 U6573.1(VOUT)
N60703527: C10640.2 R91111.2 U6572.5
N60721669: CON6201.4 ESD7507.2 R90335.2 R90760.2 R90762.2 R91140.2
N60721677: CON6201.6 ESD6204.2 R90333.2 R90763.2
N60724657: CON6201.3 ESD7508.2 R90334.2 R90759.2 R90761.2 R90765.2
N60727876: C518.1 C10637.1 CON7101.A4 CON7101.A9 CON7101.B4 CON7101.B9(VBUS4) ESD7102.1 NC246.2 R90538.1
N60821505: TP9143.1 U2001.K4
N60836746: Q776.3 Q776.6
N60836749: Q777.3 Q777.6
N60837599: Q778.3 Q778.6
N60839367: F2.1 NC302.1 R391.2
N60842437: Q779.3 Q779.6
N60918429: CON15.7 CON15.8 NC287.2 R90819.2
N61018148: C238.1 R218.1 U23.3(VIN)
N61018186: C239.1 C240.2 C243.2 L16.2 R215.1 R217.2
N61018194: L16.1 U23.4
N61018215: C243.1 R217.1 R219.1 U23.6
N61036583: NC284.2 U6.9
N61047769: CON15.6 Q55.3 Q785.3
N61065144: Q3.4 R90783.2
N61065146: Q3.3 Q3.6
N61065214: Q4.4 R90784.2
N61065216: Q4.3 Q4.6
N61071962: TP9146.1 U6559.46
N61071965: R91214.1 U6559.45
N61071968: R91213.1 U6559.44
N61071971: TP9149.1 U6559.43
N61072057: TP9151.1 U6559.31
N61072060: TP9152.1 U6559.30
N61072172: R91160.1 U124.A5
N61120403: C10631.1 C10646.1 C10660.1 NC296.1 PL2703.2 R90671.1 R90672.1
N61120487: Q797.3 Q798.2 R91148.1 R91269.2 R91330.2 U6569.7
N61120556: PP1800_ALW_PG.1 U6569.4
N61120560: R91169.1 U6569.6
N61120590: C10646.2 R90671.2 R90673.1 R91169.2
N61120594: C10662.1 U6569.5
N61126400: C10629.1 R90669.2 R91148.2 U6569.3(VIN)
N61126405: C10630.1 U6569.8
N61126408: C10630.2 PL2703.1 U6569.2
N61129418: C10665.2 R91170.1 U6576.1(VOUT)
N61132531: Q780.3 Q781.2 Q782.2 R90870.1 R91323.2
N61132598: Q781.3 R90744.1
N61132650: Q782.3 R90745.1
N61181427: R91028.2 R91029.1 U6558.B3
N61184076: R91171.2 U6558.A3(\\E\N\)
N61196473: R91174.1 U6517.H6
N61196524: R91175.1 U6517.G4
N61196760: R90868.2 U6517.A2
N61211362: CON16.47 TP9154.1
N61211380: CON16.49 TP9155.1
N61211412: CON16.19 TP9157.1
N61211428: CON16.9 TP9158.1
N61211444: CON16.11 TP9159.1
N61211467: CON16.13 TP9160.1
N61211489: CON16.50 TP9161.1
N61211505: CON16.48 TP9162.1
N61211521: CON16.46 TP9163.1
N61211537: CON16.44 R91181.1
N61211553: CON16.26 TP9165.1
N61211569: CON16.28 TP9166.1
N61211585: CON16.30 TP9167.1
N61211601: CON16.10 TP9168.1
N61211617: CON16.12 TP9169.1
N61212041: R91187.2 U6517.D7
N61212164: TP9170.1 U6548.4
N61235164: R90537.2 U6528.4
N61235166: C10393.2 R90348.2 U6528.1
N61235168: C10394.1 R90519.1 U6528.13
N61235178: R90520.2 U6528.3
N61235179: C10396.1 U6528.12
N61235182: R90512.2 U6528.5
N61235183: C10395.1 U6528.10
N61235186: C10380.2 R90479.2 U6528.6
N61235189: C10381.1 R90474.1 U6528.8(VOUT2)
N61283122: R91191.2 U6.23
N61285156: C10453.1 R90740.1
N61285894: R405.1 U6.27
N61286104: R537.2 R538.2 U6.25
N61287435: C10451.1 R90842.1 U6.31
N61287510: C10666.1 R91194.1 U6.3(VSYS)
N61290911: R91195.2 U6.29
N61302308: R91203.1 R91205.1 U6559.33
N61302311: R91202.1 R91204.1 U6559.34
N61354726: R91063.2 R91064.2 R91172.2
N61354730: C10610.2 R91063.1 U6577.C3
N61354736: R91057.1 U6577.C2
N61388546: Q732.3 Q734.3
N61404476: R91173.1 U6517.H7
N61404641: R91209.2 U6517.B7
N61407341: C6404.2 R90264.1 U6404.5(VDDIO)
N61407398: R90416.2 R90417.2 R91224.2 U6404.1
N61407402: R91219.2 R91222.2 U6404.13
N61407435: R91220.2 R91221.2 U6404.14
N61407437: C6401.1 C10446.1 R7701.1 U6404.8
N61407473: R90418.1 R91223.2 U6404.12
N61407509: R90568.2 R90569.2 U6404.4
N61407519: TP9055.1 U6404.9
N61505227: Q790.3 R91226.2 R91250.1
N61527186: R940.1 U93.25
N61543208: TP9175.1 U6559.12
N61557721: D7.1 R91161.1
N61557738: D7.4 R91326.2 R91327.2
N61557740: D7.2 R91162.1
N61557753: D7.3 R91163.1
N61558357: D2737.1(CATHODE) ESD7502.1 R90861.2 R91121.1 SW7504.1 SW7504.3
N61575845: J17.16 R91252.2
N61575919: C10627.2 J17.19 R9572.2
N61575998: J17.20 R277.2
N61591425: TP9176.1 U2001.K3
N61611783: C10667.1 R91229.2 U6579.A1(VOUT)
N61611820: C10668.2 R91228.1 U6579.A2
N61611889: R91230.2 U6579.B2
N61628180: TP9177.1 U6578.G1
N61628183: TP9178.1 U6578.H1
N61628284: R91231.2 U6578.E2
N61641304: Q791.2 Q792.3 R91232.1
N61663035: R91243.2 U6580.4
N61663068: R91244.1 U6580.1
N61723163: C141.1 NC63.2 U45.4
N61724229: Q790.1(S) Q795.3 R91250.2 R91251.1
N61744432: TP9182.1 U6578.C3
N61762663: C10430.1 C10690.1 C10691.1 C10692.1 R90662.2 R91265.1 U6570.5
N61762731: PR158.2 U6570.1
N61762735: C10426.1 PR158.1
N61762766: C10426.2 PL2702.1 PR23.1 U6570.2 U6570.3
N61762770: PC18.1 PR23.2
N61762831: C10427.1 C10428.1 C10670.1 C10693.1 PC132.1 PL2702.2 R90667.2 R90668.1
N61762862: Q766.3 R91265.2 R91270.2 R91273.1 R91281.2 U6570.6
N61762927: PP5000_ALW_PG1.1 U6570.7
N61762975: Q766.1 R90792.2
