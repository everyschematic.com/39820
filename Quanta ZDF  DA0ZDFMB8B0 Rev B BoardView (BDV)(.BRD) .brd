# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
D_GND on IN2 (solid shape): 80.38,54.74 80.45,54.72 80.49,54.66 80.55,54.56 80.65,54.52 80.69,54.52 80.71,54.51 81.06,54.16 81.88,54.16 81.97,54.11 81.97,54.02 81.96,53.96 81.95,53.91 81.96,53.86 81.97,53.81 81.96,53.71 81.88,53.67 79.72,53.67 79.54,53.85 79.53,53.87 79.53,53.89 79.48,54.02 79.35,54.07 79.32,54.06 79.29,54.05 79.19,54.06 79.15,54.15 79.15,54.43 79.19,54.51 79.29,54.52 79.32,54.51 79.35,54.51 79.42,54.52 79.48,54.56 79.49,54.56 79.57,54.5 79.68,54.48 79.77,54.5 79.87,54.55 79.88,54.56 80.16,54.56 80.35,54.74
D_GND on IN2 (solid shape): 89.29,54.54 89.34,54.46 89.34,54.17 89.59,53.93 89.58,53.89 89.64,53.77 89.78,53.73 89.78,53.73 89.83,53.7 89.82,53.64 89.76,53.57 88.17,53.57 88.17,53.65 88.22,53.69 88.25,53.72 88.29,53.73 88.4,53.73 88.45,53.72 88.54,53.75 88.61,53.82 88.68,53.87 88.77,53.85 88.82,53.8 88.95,53.8 88.98,53.78 88.98,53.77 89.04,53.74 89.1,53.72 89.28,53.89 89.1,54.07 89.04,54.05 88.98,54.02 88.98,54.01 88.95,53.99 88.93,53.99 88.82,54.1 88.83,54.17 88.89,54.22 89.01,54.31 89.07,54.46 89.07,54.47 89.11,54.52 89.16,54.53 89.19,54.55
D_GND on IN2 (solid shape): 81.69,53.25 81.77,53.21 81.79,53.13 81.78,53.1 81.8,53.04 81.83,52.98 81.85,52.92 81.83,52.86 81.8,52.8 81.78,52.75 81.73,52.68 81.65,52.67 81.62,52.68 81.59,52.68 81.41,52.51 81.59,52.34 81.61,52.34 81.63,52.33 81.81,52.14 82.37,52.14 82.42,52.19 82.7,52.19 82.73,52.18 82.75,52.14 82.73,52.06 82.46,51.8 81.13,51.8 81.05,51.84 81.03,51.92 81.04,51.97 80.99,52.09 80.87,52.14 80.8,52.12 80.73,52.07 80.7,52.07 80.4,52.07 80.3,52.13 80.32,52.24 80.59,52.5 80.61,52.51 80.77,52.59 80.84,52.77 80.83,52.85 80.79,52.93 80.78,52.96 80.79,52.99 80.82,53.04 80.83,53.1 80.82,53.13 80.84,53.21 80.92,53.25
D_GND on IN2 (solid shape): 8.7,52.11 8.75,52.11 8.76,52.09 8.85,52.04 8.95,52.02 9.06,52.04 9.15,52.11 9.4,52.11 9.44,52.07 9.44,50.89 9.76,50.57 10.47,50.57 10.56,50.5 10.78,50.5 10.86,50.56 11.11,50.56 11.16,50.51 11.16,50.2 11.09,50.12 6.03,50.12 5.3,49.4 4.54,49.4 4.01,49.18 3.79,48.65 3.81,48.47 3.88,48.31 3.87,48.21 3.79,48.16 2.71,48.16 2.71,48.26 1,48.26 0.65,48.4 0.51,48.75 0.51,51.22 3.9,51.22 5.03,50.75 5.78,51.73 5.78,51.97 6.79,51.97 6.79,51.95 6.84,51.95 6.86,51.94 7.08,51.84 7.32,51.82 7.35,51.82 7.83,52.07 8.03,52.57 8.03,52.58 8.22,52.58
D_GND on IN2 (solid shape): 88.71,39.4 88.82,39.43 88.88,39.33 88.88,39.24 88.88,39.23 88.86,39.16 88.88,39.09 88.88,39.08 88.88,38.84 88.88,38.83 88.86,38.76 88.88,38.69 88.88,38.68 88.88,38.47 89.08,38.27 89.1,38.23 89.08,38.2 89.02,38.13 89,38.13 88.89,37.88 89.16,37.84 89.24,37.88 89.31,37.84 89.4,37.79 89.53,37.81 89.56,37.79 89.64,37.71 89.64,37.68 89.32,37.36 89.29,37.34 89.27,37.31 89.2,37.28 89.02,37.33 88.91,37.28 88.84,37.24 88.76,37.28 88.75,37.3 88.74,37.31 88.74,37.64 88.51,37.88 88.51,38.01 88.51,38.04 88.52,38.05 88.61,38.3 88.44,38.5 88.37,38.57 88.4,38.66 88.41,38.67 88.41,38.87 88.41,38.89 88.43,38.91 88.5,39.03 88.5,39.18 88.5,39.19 88.5,39.24 88.5,39.26 88.51,39.28 88.61,39.37 88.68,39.37
D_GND on IN2 (solid shape): 80.43,59.21 81.72,59.21 81.72,58.59 81.54,58.41 81.37,58.41 81.37,58.4 81.16,58.4 80.33,57.58 80.33,56.43 80.27,56.34 80.16,56.36 80.14,56.38 80.08,56.41 80.08,57.5 81.14,58.55 81.14,58.6 81.21,58.6 81.26,58.58 81.31,58.57 81.45,58.62 81.5,58.75 81.48,58.83 81.43,58.9 81.37,58.93 81.31,58.94 81.22,58.92 81.16,58.85 81.08,58.85 80.94,58.72 80.94,58.63 79.89,57.58 79.89,56.41 79.82,56.36 79.71,56.35 79.65,56.44 79.65,57.88 80.33,58.56 80.37,58.55 80.5,58.87 80.19,58.74 80.19,58.69 79.46,57.96 79.46,56.11 79.43,56.09 79.33,55.99 79.29,55.86 79.3,55.81 79.31,55.76 79.31,55.7 79.27,55.64 79.24,55.62 79.21,55.59 79.05,55.59 78.51,55.05 78.51,55.05 78.26,54.8 78.26,52.69 78.56,52.38 78.56,52.14 78.46,52.03 78.17,52.03 78.12,52.08 78.12,54.88 78.12,55.26 78.35,55.49 78.35,58.05 79.56,59.26 80.37,59.26
D_GND on IN2 (solid shape): 83.54,51.98 83.63,51.95 83.76,51.82 83.77,51.8 83.78,51.78 83.78,51.32 83.73,51.23 83.62,51.23 83.56,51.26 83.49,51.27 83.3,51.19 83.22,51.01 83.22,50.97 83.21,50.96 83.09,50.84 83.09,50.75 83.08,50.7 83.13,50.57 83.25,50.52 83.36,50.56 83.42,50.66 83.45,50.72 83.51,50.75 83.57,50.76 83.62,50.78 83.73,50.78 83.78,50.7 83.78,50.33 83.73,50.25 83.64,50.24 83.62,50.24 83.59,50.25 83.5,50.22 83.44,50.15 83.43,50.14 83.37,50.08 83.27,50.06 83.2,50.13 83.11,50.28 82.94,50.34 82.88,50.33 82.78,50.29 82.73,50.29 82.71,50.33 82.65,50.44 82.54,50.49 82.51,50.48 82.42,50.51 82.39,50.58 82.39,50.95 83.27,51.84 83.29,51.84 83.32,51.84 83.41,51.87 83.47,51.93
D_GND on IN2 (solid shape): 89.97,48.97 90.02,48.88 90.02,48.79 90.26,48.55 90.29,48.53 90.33,48.52 90.81,48.52 90.9,48.48 90.9,48.38 90.89,48.33 90.88,48.27 90.87,48.25 90.72,48.1 90.72,47.38 90.71,47.35 90.69,47.33 90.66,47.32 90.63,47.32 90.61,47.34 90.58,47.38 90.57,47.4 90.58,47.5 90.53,47.62 90.4,47.67 90.37,47.66 90.34,47.65 90.24,47.66 90.2,47.75 90.2,47.83 90.13,47.9 90.13,48.06 89.92,48.27 89.93,48.29 89.75,48.47 89.58,48.3 89.6,48.23 89.65,48.15 89.66,48.13 89.66,48.1 89.94,47.82 89.94,46.63 89.66,46.36 89.55,46.33 89.48,46.43 89.48,48.05 89.28,48.26 89.27,48.33 89.26,48.36 89.27,48.46 89.35,48.51 89.54,48.59 89.61,48.77 89.61,48.81 89.64,48.9 89.73,48.93 89.75,48.92 89.81,48.93 89.86,48.96
D_GND on IN2 (solid shape): 87.34,42.22 87.43,42.19 87.53,42.22 87.54,42.23 87.73,42.23 87.74,42.22 87.83,42.19 87.93,42.22 87.94,42.23 88.07,42.23 88.1,42.2 88.12,42.14 88.1,42.07 88.11,41.84 88.34,41.83 88.41,41.85 88.48,41.82 88.85,41.45 88.85,41.16 88.85,41.11 88.88,41.05 88.88,40.96 88.85,40.91 88.8,40.92 88.52,41.2 88.04,41.2 88.01,41.2 87.99,41.23 87.87,41.33 87.72,41.28 87.69,41.27 87.65,41.28 87.47,41.33 87.31,41.25 87.29,41.23 87.27,41.23 87.2,41.23 87.18,41.25 87.06,41.33 86.93,41.29 86.86,41.27 86.79,41.3 86.72,41.35 86.64,41.37 86.46,41.37 86.3,41.44 86.13,41.39 85.95,41.39 85.79,41.44 85.64,41.38 85.62,41.37 85.55,41.37 85.48,41.41 85.46,41.49 85.46,41.58 85.44,41.66 85.43,41.74 85.49,41.8 85.54,41.82 85.67,41.82 85.67,41.8 85.67,41.72 85.73,41.66 86.29,41.66 86.37,41.73 86.4,41.76 86.45,41.82 86.54,41.82 86.55,41.81 86.73,41.82 86.8,41.98 86.81,42 86.82,42.02 86.93,42.12 86.98,42.18 87,42.19 87.08,42.19 87.13,42.22 87.14,42.23 87.33,42.23
D_GND on IN2 (solid shape): 36.62,8.09 36.6,8.08 36.41,7.62 36.86,7.42 36.89,7.42 37.35,7.42 37.95,6.81 38.01,6.77 38.08,6.76 38.62,6.76 38.71,6.7 38.69,6.58 38.46,6.36 38.42,6.3 38.41,6.23 38.41,5.77 38.4,5.76 38.4,5.43 38.66,5.24 38.71,5.2 38.68,5.15 38.63,5.11 38.59,5.1 38.56,5.12 38.42,5.22 38.25,5.21 38.14,5.28 38.01,5.31 37.65,4.95 38.01,4.59 38.14,4.62 38.25,4.69 38.35,4.67 38.46,4.7 38.5,4.7 38.52,4.68 38.59,4.58 38.69,4.51 38.72,4.47 38.93,4.26 38.93,4.26 38.9,4.23 38.99,3.79 39.38,4.01 39.45,4.09 39.56,4.07 39.84,3.79 39.86,3.68 39.76,3.61 38.62,3.61 37.13,5.1 37.13,6.13 37.12,6.2 37.08,6.26 35.36,7.99 35.34,8.1 35.43,8.16 35.83,8.16 36.08,8.4 36.08,8.51 36.12,8.6
D_GND on IN2 (solid shape): outline of 99 points within 15.48,7.9 39.99,16.37
D_GND on IN2 (solid shape): outline of 100 points within 105.32,26.98 114.05,33.19
D_GND on IN2 (solid shape): outline of 92 points within 37.39,17.75 39.2,20.84
D_GND on IN2 (solid shape): outline of 127 points within 109.91,33.66 113.01,40.34
D_GND on IN2 (solid shape): outline of 273 points within 121.01,26.45 128.03,34.09
D_GND on IN2 (solid shape): outline of 106 points within 78.85,48.84 82.99,51.88
D_GND on IN2 (solid shape): outline of 299 points within 112.92,32.81 117.79,43.31
D_GND on IN2 (solid shape): outline of 131 points within 88.94,48.09 92.6,51.67
D_GND on IN2 (solid shape): outline of 422 points within 15.15,13.77 32.52,25.8
D_GND on IN2 (solid shape): outline of 516 points within 61.07,13.37 75.98,25.06
D_GND on IN2 (solid shape): outline of 805 points within 78.85,28.03 87.69,44.38
D_GND on IN2 (solid shape): outline of 922 points within 66.44,39.78 73.85,47.4
D_GND on IN2 (solid shape): outline of 1047 points within 81.29,48.19 115.24,61.21
D_GND on IN2 (solid shape): outline of 1182 points within 14.87,19 24.78,30.94
D_GND on IN2 (solid shape): outline of 1609 points within 15.7,27.57 32.67,45.28
D_GND on IN2 (solid shape): outline of 1821 points within 28.87,4.12 47.25,27.82
D_GND on IN2 (solid shape): outline of 3426 points within 0.51,0.51 152.79,68.99
D_GND on GND (solid shape): outline of 45461 points within 0.51,0.51 152.79,68.99
D_GND on IN3 (solid shape): 65.79,38.44 65.79,35.69 62.16,35.69 62.16,35.77 62.16,35.81 62.16,35.94 62.16,35.97 62.16,38.46 65.77,38.46
D_GND on IN3 (solid shape): 112.17,32.21 112.17,31.4 112.25,31.32 112.25,29.68 109.08,29.68 109.08,29.7 109.08,29.73 109.07,30.01 108.88,30.21 108.85,30.23 108.85,32.22 108.9,32.27 112.11,32.27
D_GND on IN3 (solid shape): 52.77,21.47 52.77,21.12 52.69,21.04 50.34,21.04 49.42,20.12 46.82,20.12 45.05,20.12 44.58,20.59 44.57,20.65 44.62,20.68 44.73,20.68 45.34,20.68 45.78,20.24 45.87,20.24 46.82,20.24 49.33,20.24 49.88,20.8 49.88,21.48 50.24,21.83 52.41,21.83
D_GND on IN3 (solid shape): 142.81,19.25 142.81,13.5 140.54,11.23 140.43,11.21 140.37,11.3 140.37,11.92 140.14,12.15 138.06,12.15 137.68,12.53 137.68,14.84 137.71,14.91 137.73,14.99 137.73,17.43 138.84,18.55 140.86,18.55 140.95,18.57 141.04,18.62 141.09,18.68 141.28,18.68 142.21,19.6 142.45,19.6
D_GND on IN3 (solid shape): 111.72,37.47 111.72,36.61 111.57,36.46 111.06,36.46 110.93,36.73 110.65,36.84 110.36,36.72 110.24,36.44 110.25,36.36 110.27,36.28 110.19,36.2 109.69,36.2 108.92,36.96 108.92,37.14 109.05,37.27 109.25,37.27 109.6,36.92 110.48,36.92 110.96,37.4 111.01,37.4 111.23,37.47 111.38,37.64 111.55,37.64
D_GND on IN3 (solid shape): 114.44,57.89 114.5,57.99 114.61,57.96 114.96,57.61 114.94,57.58 114.9,57.49 114.89,57.38 114.91,57.28 114.95,57.17 114.96,57.14 114.94,57.11 114.81,56.96 114.77,56.78 114.82,56.57 114.97,56.42 114.99,56.35 115.03,56.29 115.34,55.98 115.34,55.86 115.31,55.81 115.26,55.82 114.44,56.65
D_GND on IN3 (solid shape): 125.05,67.44 125.15,67.37 125.11,67.26 124.99,67.12 124.95,66.94 125.07,66.65 125.42,66.5 125.45,66.43 125.45,66.37 125.96,65.86 126.9,65.86 127.94,64.82 127.94,64.7 126.58,64.7 125,66.27 124.27,66.27 123.73,66.81 121.85,66.81 121.76,66.9 121.75,66.95 121.8,66.99 124.17,66.99 124.63,67.44
D_GND on IN3 (solid shape): 16.94,18.14 17.05,18.06 17.18,18.04 19.97,18.04 20.23,17.79 20.23,16.64 20.25,16.52 20.32,16.41 21.36,15.37 21.47,15.3 21.6,15.27 21.93,15.27 22.11,15.09 23.92,15.09 25.76,13.26 25.87,13.19 25.99,13.16 28.75,13.16 28.81,13.11 28.81,12.77 28.78,12.74 28.69,12.66 18.75,12.66 18.47,12.94 18.47,13.06 18.46,13.11 18.43,13.15 17.92,13.66 17.89,13.68 17.84,13.69 17.72,13.69 16.72,14.69 16.72,17.63 14.99,19.36 14.99,19.67 15.17,19.84 15.24,19.84
D_GND on IN3 (solid shape): 112.63,39.83 112.63,39.41 112.52,39.3 112.02,39.3 111.84,39.12 111.84,38.13 111.7,37.99 111.54,38.03 111.46,38.17 111.46,37.93 111.4,37.93 111.25,38.14 111.01,38.22 110.97,38.21 110.98,38.26 110.99,38.32 110.29,38.6 110.58,37.91 110.61,37.91 110.6,37.86 110.6,37.81 110.6,37.76 110.38,37.55 109.71,37.55 109.55,37.71 109.55,38.1 110.27,38.83 110.49,38.83 110.63,38.97 110.64,38.97 111.68,40.01 112.45,40.01
D_GND on IN3 (solid shape): 112.95,46.45 113.04,46.36 113.04,45.9 113.03,45.87 113,45.85 112.9,45.84 112.81,45.8 112.61,45.85 112.4,45.8 112.31,45.84 112.2,45.85 112.02,45.81 111.88,45.69 111.76,45.66 111.69,45.75 111.69,45.8 111.73,45.81 111.96,45.95 112.05,46.21 111.93,46.5 111.64,46.62 111.36,46.5 111.23,46.22 111.23,46.2 111.21,46.17 111.1,46.15 111.03,46.24 111.03,47.17 111.18,47.33 112.07,47.33
D_GND on IN3 (solid shape): 26.4,16.06 26.4,15.27 26.65,15.02 32.65,15.02 32.71,15.08 32.74,15.08 33.7,16.03 34.1,16.03 34.15,15.98 34.15,14.29 34.03,14.15 33.99,13.98 34,13.93 34,13.89 33.98,13.81 33.9,13.77 29.22,13.77 29.12,13.87 26.08,13.87 24.98,14.97 24.96,15.08 25.05,15.14 25.16,15.16 25.26,15.21 25.29,15.23 25.33,15.21 25.34,15.2 26.04,15.43 25.41,15.81 25.37,15.8 25.34,15.82 25.33,15.82 24.89,15.93 24.62,15.57 24.56,15.48 24.45,15.51 24.08,15.87 24.05,15.96 24.1,16.03 24.23,16.14 24.3,16.29 26.17,16.29
D_GND on IN3 (solid shape): 42.07,36.45 42.07,36.06 42.03,36.06 42,36.03 41.97,36.02 41.93,36.02 41.51,35.6 41.51,35.54 41.47,35.5 41.47,35.21 41.44,35.19 41.4,35.19 41.12,35.09 40.98,34.82 40.97,34.77 40.88,34.77 40.88,34.86 40.69,35.04 40.7,35.13 40.58,35.42 40.29,35.54 40.24,35.54 39.95,35.42 39.83,35.13 39.84,35.1 39.78,35 39.66,35.02 38.61,36.07 38.04,36.07 37.95,36.12 37.95,36.22 37.99,36.32 38.01,36.43 37.6,36.84 37.19,36.43 37.21,36.32 37.25,36.22 37.25,36.12 37.16,36.07 35.36,36.07 35.26,36.14 35.29,36.25 35.34,36.29 35.4,36.32 35.46,36.3 35.59,36.22 35.73,36.2 36.01,36.32 36.13,36.61 36.12,36.72 36.07,36.83 36.06,36.91 36.11,36.97 41.55,36.97
D_GND on IN3 (solid shape): 110.78,45.3 110.82,45.31 110.85,45.3 110.89,45.26 110.62,44.99 109.08,44.99 108.97,44.97 108.88,44.91 108.3,44.33 107.52,44.33 107.41,44.31 107.32,44.25 106.97,43.9 106.83,43.9 106.4,44.32 106.31,44.38 106.21,44.41 104.28,44.41 104.17,44.38 104.08,44.32 103.57,43.82 103.51,43.72 103.49,43.62 103.49,43.58 103.47,43.57 103.73,42.88 104.11,43.51 104.09,43.54 104.39,43.85 106.09,43.85 106.52,43.42 106.61,43.36 106.71,43.34 107.09,43.34 107.19,43.36 107.29,43.42 107.64,43.77 108.42,43.77 108.43,43.77 108.52,43.71 108.5,43.6 107.91,43.01 105.34,43.01 105.23,42.99 105.13,42.92 105.06,42.85 104.97,42.82 104.9,42.77 104.89,42.76 103.05,42.76 102.6,43.21 102.6,44.94 102.83,45.17 105.98,45.17 106.05,45.13 106.08,45.06 106.08,45.01 106.18,44.75 106.42,44.61 106.43,44.61 106.48,44.56 106.48,44.55 106.61,44.27 106.88,44.16 107.17,44.28 107.29,44.57 107.28,44.68 107.24,44.77 107.28,44.88 107.29,45.05 107.32,45.13 107.39,45.17 110.65,45.17
D_GND on IN3 (solid shape): 149.97,35.08 149.97,32.16 148.95,31.15 147.89,31.15 147.43,31.61 147.43,32.57 147.41,32.67 147.36,32.75 146.34,33.77 146.3,33.8 146.26,33.82 146.2,33.89 146.23,33.98 146.27,34.02 146.31,34.02 146.6,34.14 146.72,34.42 146.71,34.52 146.67,34.61 146.66,34.64 146.92,34.91 147.78,34.91 148.13,34.55 148.16,34.47 148.11,34.39 147.97,34.24 147.91,34.04 147.94,33.89 148.03,33.75 148.06,33.68 148.03,33.61 147.94,33.48 147.91,33.32 148.32,32.91 148.73,33.32 148.72,33.36 148.71,33.42 148.92,33.63 148.96,33.7 148.98,33.78 148.98,34.48 148.96,34.56 148.92,34.63 148.09,35.46 148.02,35.5 147.95,35.52 147.46,35.52 147.46,35.72 148.19,35.72 149.18,34.72 149.18,33.11 148.62,32.54 148.57,32.54 148.29,31.85 148.98,32.14 148.98,32.18 149.62,32.82 149.67,32.9 149.69,33 149.69,34.83 149.67,34.93 149.62,35.01 148.47,36.15 148.39,36.21 148.29,36.23 147.81,36.23 147.71,36.29 147.74,36.4 148.04,36.71 148.34,36.71
D_GND on IN3 (solid shape): 43.49,20.59 43.52,20.64 43.58,20.63 44.71,19.5 44.77,19.44 44.86,19.44 46.82,19.44 49.7,19.44 50.62,20.36 50.87,20.36 50.97,20.3 50.95,20.19 50.55,19.79 50.53,19.79 50.28,19.69 50.15,19.45 50.13,19.42 50.1,19.41 50.05,19.41 49.64,19.01 50.05,18.6 50.31,18.7 50.45,18.94 50.47,18.97 50.5,18.98 50.55,18.98 50.84,19.1 50.96,19.39 50.95,19.48 51.04,19.57 51.15,19.59 51.22,19.5 51.29,19.3 51.46,19.16 51.49,19.15 51.49,18.51 51.49,18.5 51.24,18.24 51.19,18.25 50.91,18.13 50.79,17.84 50.79,17.79 50.27,17.28 46.74,17.28 46.44,16.97 46.03,16.97 45.88,17.12 45.68,17.18 45.44,17.1 45.29,16.89 45.28,16.87 44.08,16.87 43.49,17.46 43.49,18.43 43.56,18.52 43.67,18.5 44.53,17.63 44.64,17.63 45.46,17.63 45.6,17.52 45.78,17.48 46.19,17.89 45.78,18.29 45.6,18.25 45.46,18.14 44.74,18.14 43.75,19.14 43.75,20.29 43.49,20.55
D_GND on IN3 (solid shape): outline of 341 points within 16.52,3.66 35.21,9.3
D_GND on IN3 (solid shape): outline of 379 points within 54.67,13.09 74.54,24.65
D_GND on IN3 (solid shape): outline of 362 points within 77.25,36.21 86.88,41.47
D_GND on IN3 (solid shape): outline of 434 points within 41.7,20.92 59.31,30.61
D_GND on IN3 (solid shape): outline of 447 points within 98.56,52.11 114.54,60.71
D_GND on IN3 (solid shape): outline of 526 points within 30.23,4.32 47.78,10.09
D_GND on IN3 (solid shape): outline of 680 points within 35.72,10.7 58.76,15.54
D_GND on IN3 (solid shape): outline of 855 points within 40.17,3.66 66,8.11
D_GND on IN3 (solid shape): outline of 1188 points within 14.45,18.39 34.88,33.56
D_GND on IN3 (solid shape): outline of 5811 points within 0.51,0.51 152.79,68.99
D_GND on IN4 (solid shape): 53.04,47 53.04,45.81 53.66,45.19 53.66,40.75 52.64,39.73 51.76,39.73 51.63,39.86 51.63,46.32 51.92,46.61 52.02,46.56 52.13,46.54 52.39,46.64 52.49,46.9 52.48,46.99 52.44,47.07 52.44,47.17 52.53,47.22 52.82,47.22
D_GND on IN4 (solid shape): 97.57,51.44 97.63,51.54 97.74,51.52 97.98,51.27 100.2,51.27 100.29,51.21 100.27,51.1 100.07,50.9 100.07,49.51 100.47,49.11 101.93,49.11 102.73,49.91 102.73,50.02 102.79,50.11 102.9,50.09 103.9,49.09 104.4,49.09 104.49,49.03 104.47,48.92 104.33,48.77 104.33,48.35 104.26,48.26 104.15,48.28 104.08,48.35 103.52,48.35 103.26,48.62 98.53,48.62 97.57,49.58
D_GND on IN4 (solid shape): 92.44,59.11 92.46,59.1 92.74,58.82 92.87,58.84 93.01,58.78 93.07,58.64 93.05,58.5 95.66,55.9 95.79,55.92 95.93,55.86 95.99,55.72 95.99,55.67 95.99,55.6 96.02,55.52 96.02,55.3 95.95,55.23 95.85,55.25 92.17,58.94 92.15,59.04 92.22,59.11
D_GND on IN4 (solid shape): 87.47,34.96 87.55,34.92 87.57,34.83 87.56,34.79 87.56,34.75 87.57,34.67 87.61,34.59 87.64,34.52 87.61,34.46 87.57,34.4 87.55,34.33 87.57,34.26 87.61,34.2 87.63,34.13 87.6,34.05 87.5,33.95 87.21,33.95 87.14,33.99 87.12,34.07 87.12,34.16 87.14,34.18 87.19,34.24 87.21,34.33 87.03,34.51 86.84,34.33 86.85,34.26 86.89,34.21 86.91,34.14 86.88,34.07 86.84,34.03 86.81,34.04 86.77,34.05 86.72,34.05 86.54,33.97 86.46,33.79 86.46,33.75 86.44,33.67 86.36,33.63 86.06,33.63 85.95,33.74 85.95,33.95 86.12,34.13 86.12,34.43 86.07,34.48 86.07,34.68 86.12,34.74 86.12,34.81 86.24,34.92 86.75,34.92 86.78,34.96
D_GND on IN4 (solid shape): 112.56,45.07 112.66,45.01 112.64,44.9 112.58,44.53 112.89,44.31 112.92,44.29 112.94,44.26 112.94,43.3 112.94,43.28 112.94,42.78 112.81,42.66 112.52,42.66 111.9,42.04 111.79,41.93 111.68,41.91 111.61,41.99 111.52,42.19 111.34,42.3 111.22,42.53 110.95,42.56 110.94,42.56 110.88,42.56 110.88,42.63 111.04,42.79 111.05,42.79 111.25,43 111.16,43.28 111.12,43.35 111.15,43.43 111.46,43.74 111.46,43.99 111.55,44.19 111.48,44.39 111.46,44.5 111.55,44.56 111.64,44.56 111.83,44.38 112.15,44.38 112.33,44.56 112.33,44.7 112.34,44.71 112.37,44.82 112.36,44.94 112.38,45.03 112.46,45.07
D_GND on IN4 (solid shape): outline of 103 points within 34.3,41.49 51.27,47.22
D_GND on IN4 (solid shape): 39.36,18.3 39.36,18.23 39.31,18.18 39.23,17.95 39.44,17.83 39.44,17.83 39.86,17.83 39.94,17.79 39.96,17.71 39.99,17.55 40.13,17.47 40.16,17.41 40.19,17.36 40.21,17.26 40.14,17.2 40.01,17.12 39.92,17 39.84,16.94 39.75,16.97 39.72,17 39.69,17.09 39.74,17.17 39.73,17.64 39.37,17.33 39.35,17.28 39.3,17.27 39.26,17.28 39.2,17.32 39.18,17.39 38.73,17.59 38.94,17.14 39.01,17.12 39.04,17.06 39.1,16.97 39.2,16.92 39.26,16.88 39.28,16.81 39.28,16.76 39.3,16.71 39.3,16.11 39.15,15.96 37.88,15.96 37.45,16.39 37.4,16.44 37.35,16.47 37.28,16.53 37.3,16.63 37.35,16.75 37.34,16.88 37.34,16.89 37.34,16.95 37.46,16.95 37.47,16.91 37.72,16.79 37.82,17.04 37.82,17.12 37.88,17.18 37.93,17.2 37.97,17.22 38.04,17.25 38.1,17.22 38.14,17.18 38.14,16.77 38.13,16.75 38.1,16.75 38.01,16.43 38.32,16.54 38.32,16.56 38.41,16.65 38.41,17.29 38.11,17.59 38.11,17.81 38.22,17.92 38.24,17.91 38.44,17.99 38.44,18.2 38.43,18.3 38.52,18.36 39.34,18.36
D_GND on IN4 (solid shape): outline of 38695 points within 0.51,0.51 152.79,68.99
D_GND on IN5 (solid shape): 50.99,22.52 50.99,19.58 51.01,19.55 51.02,19.53 51.07,19.37 51.21,19.27 51.25,19.26 51.25,18.51 50.93,18.2 50.62,18.2 50.43,18.39 50.43,22.64 50.51,22.72 50.78,22.72
D_GND on IN5 (solid shape): 74.51,30.93 74.51,30.09 77.42,27.18 80.37,27.18 80.48,27.08 80.48,26.51 80.14,26.18 80.08,26.09 80.06,25.98 80.14,25.78 80.34,25.7 80.45,25.72 80.54,25.78 80.57,25.82 80.69,25.84 80.75,25.75 80.75,25.05 80.45,24.75 64.58,24.75 64.4,24.92 64.4,25.9 65.02,26.52 65.02,30.47 66,31.46 73.98,31.46
D_GND on IN5 (solid shape): 105.04,37.73 105.1,37.63 105.1,36.98 105.04,36.89 104.93,36.91 104.84,36.97 104.73,36.99 104.45,36.72 104.73,36.44 104.84,36.46 104.93,36.52 105.04,36.54 105.1,36.45 105.1,32.63 101.91,29.44 101.74,29.44 101.71,29.47 101.71,29.49 104.15,31.93 104.18,31.97 104.19,32.01 104.19,35.85 104.18,35.9 104.15,35.93 104.01,36.08 104.01,36.75 104.25,36.99 104.28,37.03 104.29,37.08 104.29,37.09 104.3,37.13 104.52,37.23 104.6,37.42 104.59,37.47 104.58,37.51 104.6,37.61 104.7,37.64 104.75,37.64 104.84,37.66 104.93,37.71
D_GND on IN5 (solid shape): outline of 128 points within 56.07,13.81 75.12,24.11
D_GND on IN5 (solid shape): outline of 137 points within 78.29,29.68 82.4,44.63
D_GND on IN5 (solid shape): outline of 187 points within 101.74,26.8 105.56,32.48
D_GND on IN5 (solid shape): outline of 243 points within 48.45,26.28 59.58,35.08
D_GND on IN5 (solid shape): outline of 249 points within 54.77,11.92 58.76,14.15
D_GND on IN5 (solid shape): outline of 501 points within 118.85,14.87 137.9,36.71
D_GND on IN5 (solid shape): outline of 762 points within 76.82,47.12 102.85,58.68
D_GND on IN5 (solid shape): outline of 802 points within 55.09,35.27 69.28,47.72
D_GND on IN5 (solid shape): outline of 2182 points within 81.86,29.93 116.12,51.16
D_GND on IN5 (solid shape): outline of 2593 points within 0.51,0.51 152.79,68.99
D_GND on IN5 (solid shape): outline of 2432 points within 33.76,9.4 54.74,38.11
DA7219_VDD on TOP (solid shape): 14.28,31.55 14.28,30.44 14.18,30.33 13.78,30.33 13.37,29.93 12.66,29.93 12.56,30.03 12.56,30.23 12.66,30.33 12.86,30.33 13.37,30.84 13.37,31.45 13.57,31.65 14.18,31.65
DA7219_VDDIO on TOP (solid shape): 14.28,29.93 14.28,28.81 14.08,28.61 13.27,28.61 13.17,28.71 13.17,29.22 13.27,29.32 13.57,29.32 13.67,29.42 13.67,29.93 13.78,30.03 14.18,30.03
EC_RST_ODL on BOTTOM (solid shape): 50.3,19.72 51.72,19.72 52.38,19.06 52.38,17.26 52.38,17.13 52.42,17.09 52.42,15.86 51.76,15.21 51.38,15.21 51.19,15.4 51.19,15.73 51.72,16.26 51.72,18.85 51.39,19.18 49.96,19.18 49.03,20.11 48.36,20.11 47.89,19.64 47.89,19.25 47.84,19.19 47.82,19.12 47.82,18.68 47.79,18.65 47.33,18.65 47.25,18.73 47.25,19.88 48.06,20.68 49.34,20.68
EC_RST_ODL on IN4 (solid shape): 52.05,16.14 52.05,15.5 51.8,15.25 51.04,15.25 50.78,14.99 50.78,13.79 50.67,13.68 50.49,13.55 50.43,13.34 50.44,13.25 50.48,13.16 50.22,12.91 49.77,12.91 49.48,12.79 49.34,12.47 49.31,12.45 48.07,12.45 47.94,12.58 47.94,13.11 48.14,13.32 48.25,13.32 48.27,13.3 48.4,13.22 48.55,13.19 48.57,13.19 48.83,13.28 48.97,13.52 49.18,13.52 49.64,13.98 49.64,15.12 50.78,16.26 51.93,16.26
EDP_BL_VOUT on BOTTOM (solid shape): 62.03,47.61 62.03,45.87 60.85,44.68 51.54,44.68 51.11,44.25 51.11,41.71 50.76,41.36 47.86,41.36 47.43,41.79 47.43,46.39 48.42,47.38 58.05,47.38 58.43,47.76 61.88,47.76
EDP_BL_VOUT on BOTTOM (solid shape): 50.2,38.18 50.2,35.62 50.2,35.49 49.9,35.49 49.9,36.8 49.7,36.8 49.7,35.49 49.4,35.49 49.4,36.8 49.2,36.8 49.2,35.49 48.9,35.49 48.9,36.99 48.09,37.8 48.09,38.23 48.1,38.24 50.14,38.24
EDP_BL_VOUT on IN3 (solid shape): 49.17,43.13 49.26,43.09 49.27,42.99 49.24,42.91 49.23,42.83 49.64,42.42 50.05,42.83 50.04,42.91 50.01,42.99 50.02,43.09 50.11,43.13 51.44,43.13 51.52,43.09 51.54,43.01 51.52,42.94 51.52,42.88 51.57,42.67 51.72,42.5 51.74,42.47 51.73,42.43 51.67,42.31 51.65,42.17 51.78,41.85 52.1,41.71 52.41,41.83 52.59,42.19 52.74,42.23 52.81,42.24 52.9,42.23 52.94,42.15 53.08,41.84 53.4,41.71 53.72,41.85 53.86,42.17 53.82,42.35 53.71,42.5 53.7,42.54 53.71,42.57 53.77,42.66 53.81,42.75 53.89,42.82 53.98,42.79 54.17,42.61 54.27,42.53 54.4,42.48 54.44,42.48 54.44,39.28 52.87,37.7 51.12,37.7 51.04,37.74 51.03,37.83 51.03,37.88 51.04,37.92 50.63,38.33 50.22,37.92 50.23,37.88 50.24,37.83 50.22,37.74 50.14,37.7 48.04,37.7 47.79,37.95 47.79,42.7 47.8,42.74 47.83,42.75 48,42.79 48.13,42.89 48.38,43.13
EMI_VDD2 on TOP (solid shape): 113.59,42.33 113.59,41.53 113.55,41.48 113.37,41.48 113.24,41.61 112.46,41.61 112.37,41.7 112.37,42.27 112.48,42.38 113.54,42.38
EMI_VDD2 on TOP (solid shape): 108.32,48.26 108.32,46.49 108.19,46.36 105.93,46.36 105.83,46.45 105.83,48.26 106.03,48.46 108.12,48.46
EMI_VDD2 on BOTTOM (solid shape): 84.87,42.53 84.87,42.48 84.92,42.43 84.92,42.05 84.92,42.05 84.92,41.74 85,41.66 85.57,41.66 85.61,41.69 85.77,41.69 86.67,41.69 86.75,41.62 86.75,41.47 86.67,41.38 84.52,41.38 84.44,41.47 84.44,42.51 84.49,42.56 84.84,42.56
EMI_VDD2 on BOTTOM (solid shape): 79.19,53.2 79.19,53.14 79.2,53.1 79.2,52.9 79.24,52.85 79.24,52.82 79.27,52.82 79.84,52.25 79.84,47.38 79.64,47.19 78.12,47.19 78.04,47.26 78.04,47.55 78.06,47.57 78.27,47.57 78.34,47.63 78.34,47.89 78.49,48.11 78.39,48.35 78.39,48.35 78.26,48.41 78.12,48.4 78.09,48.39 78.01,48.47 78.01,53.6 78.13,53.72 78.67,53.72
EMI_VDD2 on IN1 (solid shape): 85.74,41.59 86.01,41.59 86.05,41.63 87.29,41.63 87.33,41.67 87.43,41.67 87.56,41.54 87.56,41.45 87.45,41.34 86.9,41.34 86.8,41.24 86.8,41.06 86.74,41 85.35,41 85.28,41.08 85.28,41.3 85.16,41.41 84.92,41.41 84.82,41.31 84.82,41.08 84.77,41.03 84.56,41.03 84.51,41.08 84.51,41.43 84.52,41.43 84.52,41.67 84.62,41.77 85.56,41.77
EMI_VDD2 on IN2 (solid shape): 108.13,48.17 108.13,46.72 108.03,46.62 106.05,46.62 106.04,46.63 106.04,48.03 106.46,48.45 107.85,48.45
EMI_VDD2 on IN3 (solid shape): outline of 2309 points within 75.41,40.81 115.48,59.86
EMI_VDD2 on IN4 (solid shape): 79.16,53.59 79.16,53.09 79.12,53.01 79.02,53 78.98,53.01 78.93,53.02 78.66,52.75 78.93,52.49 78.98,52.49 79.02,52.51 79.07,52.51 79.12,52.5 79.13,52.49 79.15,52.46 79.16,52.41 79.16,51.29 79.1,51.26 79.08,51.24 79.04,51.24 79,51.26 78.89,51.36 78.75,51.4 78.44,51.09 78.75,50.79 78.84,50.8 78.92,50.84 78.96,50.85 78.99,50.82 79.1,50.72 79.25,50.69 79.35,50.7 79.44,50.75 79.45,50.76 79.49,50.78 79.81,50.46 79.81,49.65 79.81,49.61 79.79,49.58 79.31,49.24 79.79,48.9 79.81,48.87 79.81,48.84 79.81,47.64 79.81,47.64 79.81,47.51 79.76,47.49 79.59,47.37 79.52,47.17 79.49,47.1 79.42,47.07 79.21,47.07 78.8,47.07 78.62,47.25 78.62,47.82 78.74,47.93 78.74,48.34 78.78,48.34 79.03,48.9 78.42,48.85 78.34,48.8 78.26,48.83 77.92,49.16 77.92,51.64 78.19,51.91 78.21,51.9 78.24,51.94 78.27,51.93 78.68,52.25 78.35,52.64 78.28,52.67 78.25,52.74 78.25,53.58 78.39,53.71 79.04,53.71
EMI_VDDQ on TOP (solid shape): 96.27,51.2 96.27,50.15 96.27,50.15 96.27,49.96 96.1,49.8 93.84,49.8 93.61,50.03 93.61,51.12 93.84,51.35 96.12,51.35
EMI_VDDQ on BOTTOM (solid shape): 87.13,43.42 87.13,43.07 86.65,42.58 86.64,42.57 86.65,42.52 86.65,42.41 86.65,42.4 86.65,42 86.46,41.81 85.56,41.81 85.52,41.76 85.06,41.76 85.02,41.8 85.02,42.15 85.07,42.2 85.66,42.2 85.81,42.35 85.81,43.42 85.94,43.55 87,43.55
EMI_VDDQ on IN1 (solid shape): 111.23,43.14 111.23,42.58 110.77,42.11 110.67,42.11 109.88,41.32 109.77,41.32 109.56,41.11 109.56,41.1 109.11,41.1 109.05,41.16 109.05,41.28 109.09,41.36 109.18,41.38 109.22,41.37 109.25,41.37 109.36,41.39 109.45,41.45 110.09,42.09 110.15,42.18 110.17,42.29 110.17,42.98 110.35,43.17 111.21,43.17
EMI_VDDQ on IN2 (solid shape): 111.42,46.51 111.42,46.49 111.32,46.36 111.29,46.21 111.29,46.14 111.31,46.08 111.32,46 111.31,45.94 111.34,45.79 111.44,45.66 111.44,44.91 111.36,44.91 111.22,44.78 111.22,44.16 111.36,44.02 111.36,44.01 111.44,43.94 111.44,42.79 111.18,42.53 110.83,42.53 110.7,42.65 110.7,43.08 110.85,43.23 110.85,43.71 110.59,43.98 110.07,43.98 110,44.05 109.77,44.05 109.77,44.05 109.63,44.18 109.63,45.4 109.6,45.44 109.6,45.46 109.33,45.73 109.33,46.4 109.63,46.7 111.23,46.7
EMI_VDDQ on IN2 (solid shape): 82.73,59.73 82.73,59.12 82.55,58.94 82.53,58.94 82.43,58.89 82.37,58.78 82.37,58.76 82.37,58.57 82.36,58.55 82.35,58.53 81.08,57.26 81.08,56.13 81.81,55.4 81.86,55.4 82.13,55.13 82.13,54.67 82,54.55 81.8,54.55 81.41,54.93 81.2,54.93 81.19,54.94 80.96,54.94 80.95,54.93 80.63,54.93 80.5,54.8 80.48,54.79 80.45,54.79 80.41,54.8 80.32,54.8 80.14,54.62 79.88,54.62 79.84,54.61 79.75,54.55 79.68,54.54 79.6,54.56 79.53,54.6 79.51,54.62 79.46,54.62 79.44,54.6 79.4,54.58 79.35,54.57 79.33,54.57 79.28,54.59 79.25,54.59 79.22,54.61 79.21,54.64 79.21,54.83 79.43,55.05 79.7,55.05 79.73,55.08 79.75,55.08 79.94,55.08 80.17,55.31 80.83,55.31 80.88,55.35 80.88,55.61 80.55,55.94 80.54,56.11 80.5,56.18 80.48,56.22 80.48,57.51 81.22,58.25 81.43,58.25 81.43,58.26 81.6,58.26 81.87,58.53 81.87,59.29 81.8,59.37 80.49,59.37 80.39,59.47 80.39,59.73 80.48,59.82 82.63,59.82
EMI_VDDQ on IN3 (solid shape): outline of 1596 points within 79.08,40.86 110.83,56.73
H1_AP_FLASH_EN on TOP (solid shape): 63.01,19.55 63.01,16.02 62.53,15.54 61.81,15.54 61.73,15.62 61.73,16.03 61.83,16.14 62.11,16.14 62.16,16.19 62.16,16.27 62.17,16.3 62.17,16.33 62.17,16.94 62.17,16.97 62.16,17 62.16,17.1 62.14,17.13 62.04,17.13 61.83,17.33 61.83,17.43 61.12,18.14 61.12,19.28 61.53,19.69 62.87,19.69
HP_R on TOP (solid shape): 7.78,37.24 7.78,35 7.66,34.88 7.3,34.88 7.2,34.98 7.2,36.61 7.07,36.73 7.07,37.29 7.15,37.37 7.65,37.37
ISL9238C_LG1 on BOTTOM (solid shape): 132.44,36.33 132.44,35.72 132.24,35.52 131.07,35.52 130.92,35.67 130.92,36.28 131.12,36.48 132.29,36.48
ISL9238C_LG2 on TOP (solid shape): 130.08,28.56 130.08,28 129.75,27.67 128.41,27.67 128.2,27.87 128.2,28.12 128.21,28.13 128.27,28.19 128.3,28.26 128.29,28.67 128.33,28.71 129.93,28.71
ISL9238C_LG2 on BOTTOM (solid shape): 130.11,29.14 130.11,28.38 129.88,28.15 129.07,28.15 128.86,28.35 128.86,29.27 128.96,29.37 129.88,29.37
ISL9238C_PH1 on TOP (solid shape): 131.78,30.59 131.78,30.23 131.48,29.93 130.87,29.93 130.77,30.03 129.8,30.03 129.75,30.09 129.75,30.57 129.76,30.58 129.76,30.59 129.85,30.69 131.68,30.69
ISL9238C_PH1 on BOTTOM (solid shape): outline of 113 points within 127.77,30.13 137.52,40.04
ISL9238C_PH2 on TOP (solid shape): 127.54,26.88 127.54,26.6 127.29,26.35 126.22,26.35 125.92,26.65 125.92,27.26 125.94,27.29 127.14,27.29
ISL9238C_PH2 on BOTTOM (solid shape): 137.52,29.29 137.52,25.28 139.05,23.76 139.05,22.23 138.92,22.1 135.29,22.1 134.48,22.92 133.61,22.92 131.07,25.46 125.05,25.46 124.95,25.56 124.95,28 130.51,28 132.19,29.67 137.14,29.67
ISL9238C_UG1 on TOP (solid shape): 129.94,33.06 130.27,33.06 130.67,32.67 130.67,32.16 130.49,31.98 129.73,31.98 129.6,32.11 129.6,32.5 129.63,32.55 129.64,32.61 129.64,32.99 129.64,33.02 129.7,33.08 129.93,33.08
ISL9238C_UG1 on BOTTOM (solid shape): 126.7,35.92 126.7,35.46 126.55,35.31 125.69,35.31 125.43,35.57 125.43,36.12 126.5,36.12
ISL9238C_UG2 on BOTTOM (solid shape): 130.36,23.78 130.36,23.02 130.31,22.97 128.94,22.97 128.84,23.07 128.84,23.83 128.89,23.88 130.26,23.88
PP1000_MIPIBRDG on TOP (solid shape): 66.89,47.84 66.89,46.7 66.84,46.64 65.49,46.64 65.46,46.67 65.46,47.77 65.57,47.88 66.85,47.88
PP1000_MIPIBRDG on TOP (solid shape): 71.92,34.35 72.68,34.35 72.75,34.27 72.75,33.92 72.63,33.79 71.41,33.79 71.15,34.05 71.15,34.59 71.24,34.68 71.59,34.68
PP1000_MIPIBRDG_A on BOTTOM (solid shape): 64.3,42.81 65.62,42.81 65.69,42.73 65.69,42.45 65.64,42.4 65.46,42.4 65.43,42.4 64.76,42.4 64.73,42.4 64.69,42.4 63.81,42.4 63.48,42.73 63.48,43.08 63.56,43.16 63.94,43.16
PP1000_MIPIBRDG_D on BOTTOM (solid shape): 66.48,43.67 66.48,43.34 66.07,42.93 65.71,42.93 65.68,42.96 64.37,42.96 64.32,43.01 64.32,43.28 64.35,43.36 64.43,43.39 64.82,43.39 64.86,43.39 64.91,43.41 65.08,43.41 65.13,43.39 65.17,43.39 65.55,43.39 65.59,43.39 65.64,43.41 65.67,43.41 66,43.74 66.4,43.74
PP1800_ALW on TOP (solid shape): 31.45,34.75 31.45,33.74 31.42,33.71 30.34,33.71 30.31,33.74 30.31,34.73 30.46,34.88 31.33,34.88
PP1800_ALW on TOP (solid shape): 128.83,14.56 128.83,13.56 128.53,13.26 127.96,13.26 127.87,13.32 127.77,13.34 127.74,13.37 127.74,14.25 127.73,14.26 127.73,14.68 127.88,14.82 128.57,14.82
PP1800_ALW on TOP (solid shape): 136.15,65.46 136.15,64.5 136.1,64.45 135.12,64.45 134.97,64.6 134.97,65.17 134.83,65.31 134.01,65.31 133.41,65.92 132.85,65.92 132.67,65.74 132.67,64.14 132.62,64.09 131.91,64.09 131.81,64.19 131.81,65.89 132.85,66.94 134.68,66.94
PP1800_ALW on BOTTOM (solid shape): 87.08,18.01 87.13,17.99 87.18,17.98 88.08,17.98 88.27,17.79 88.27,16.21 88.58,15.91 88.58,13.9 87.39,12.71 85.95,12.71 85.79,12.88 85.79,13.99 86.67,14.88 86.67,15.11 86.64,15.15 86.64,16.81 86.42,17.02 86.42,17.99 86.44,18.01
PP1800_ALW on BOTTOM (solid shape): 130.66,47.31 130.74,47.3 130.83,47.31 130.92,47.34 132.81,47.34 132.82,47.3 132.88,47.23 132.96,47.2 133.35,47.2 133.41,47.22 133.46,47.26 133.61,47.26 133.66,47.22 133.73,47.2 134.11,47.2 134.17,47.22 134.23,47.26 134.57,47.26 134.59,47.24 134.65,47.19 134.73,47.18 136,47.18 136.08,47.19 136.14,47.24 136.24,47.34 139.54,47.34 139.56,47.33 142.5,47.33 143.06,46.77 143.06,45.88 142.4,45.22 121.27,45.22 121.01,45.47 121.01,46.91 121.45,47.34 130.57,47.34
PP1800_ALW on IN5 (solid shape): outline of 2419 points within 68.94,2.03 143.24,67.47
PP1800_AP on TOP (solid shape): 42.86,39.18 43.28,39.18 43.33,39.13 43.33,38.62 43.27,38.56 42.83,38.56 42.11,39.28 41.63,39.28 41.58,39.34 41.58,39.53 41.61,39.56 42.48,39.56
PP1800_AP on TOP (solid shape): 26.93,35.57 26.78,35.41 26.39,35.41 25.39,35.26 25.31,35.26 25.26,35.31 25.26,36.18 25.38,36.3 26.93,36.3
PP1800_AP on TOP (solid shape): 41.18,39.08 41.18,38.76 41.41,38.54 41.41,36.18 41.35,36.13 41.08,36.13 41.03,36.18 41.03,38.17 40.62,38.58 40.62,39.15 40.65,39.19 41.08,39.19
PP1800_AP on TOP (solid shape): 113.13,56.02 113.13,55.74 113.11,55.72 112.55,55.72 112.47,55.64 112.47,55.29 112.48,55.28 112.48,55.17 112.56,55.1 112.91,55.1 113.01,55 113.01,54.7 112.96,54.65 112.65,54.65 112.4,54.9 111.71,54.9 111.28,54.47 110.11,54.47 109.99,54.6 109.99,55.89 110.19,56.1 113.06,56.1
PP1800_AP on TOP (solid shape): 90.75,26.96 91.1,26.96 91.14,26.91 91.14,25.83 90.46,25.83 90.23,26.06 90.23,26.42 90.08,26.57 90.01,26.57 89.98,26.58 89.95,26.58 89.67,26.58 89.63,26.58 89.6,26.57 89.46,26.57 89.3,26.41 89.3,25.79 89.13,25.62 88.65,25.62 88.53,25.49 88.53,25.18 88.3,24.96 87.74,24.96 87.64,25.06 87.64,26.95 87.76,27.08 90.64,27.08
PP1800_AP on TOP (solid shape): 97.57,42.68 97.57,42.04 97.47,41.94 96.99,41.94 96.76,41.71 96.76,35.12 96.81,35.07 96.81,34.3 95.86,33.36 94.9,33.36 94.72,33.54 94.72,34.56 95.18,35.01 95.89,35.01 96.11,35.23 96.11,35.28 96.13,35.31 96.13,35.36 96.14,35.4 96.15,35.44 96.14,35.48 96.13,35.52 96.13,35.57 95.97,35.74 95.97,36.18 96.14,36.36 96.14,36.64 96.09,36.69 96.09,36.83 96.15,36.92 96.17,37.02 96.17,37.05 95.89,37.33 95.61,37.05 95.61,37.02 95.63,36.93 95.68,36.84 95.68,36.78 95.62,36.71 95.31,36.71 95.23,36.79 95.23,37.86 95.3,37.93 95.86,37.93 96.31,38.38 96.31,40.16 95.97,40.51 95.97,40.77 95.98,40.79 95.98,41.52 95.99,41.53 95.99,42.21 96.26,42.47 96.6,42.47 96.91,42.78 97.47,42.78
PP1800_AP on BOTTOM (solid shape): 108,56.07 108,55.67 108.16,55.51 109.68,55.51 109.69,55.53 110.77,55.53 111.13,55.17 111.13,54.35 110.87,54.09 107.47,54.09 107.04,54.52 107.04,56.16 107.1,56.23 107.85,56.23
PP1800_AP on BOTTOM (solid shape): 97,32.81 98.07,32.81 98.07,32.81 98.49,32.81 98.81,32.49 98.81,32.48 98.91,32.34 99.08,32.29 99.27,32.37 99.35,32.57 99.32,32.7 99.23,32.8 99.18,32.87 99.21,32.95 99.27,33.01 106.81,33.01 108.34,31.48 108.34,30.34 108.18,30.18 106.75,30.18 106.21,30.72 102.54,30.72 102.39,30.87 102.39,31.23 102.16,31.46 101.25,31.46 101.1,31.31 101.1,30.8 101.02,30.72 98.28,30.72 98.06,30.51 98.06,30.45 98.05,30.43 98.05,26.94 97.11,26 88.91,26 88.65,26.25 88.65,27.5 89.35,28.19 90.07,28.19 90.08,28.2 93.19,28.2 95.63,30.65 95.63,32.25 95.32,32.56 95.32,32.59 95.15,32.76 95.13,32.76 94.9,32.98 94.9,33.83 94.92,33.84 94.92,33.89 95.07,34.04 95.77,34.04
PP1800_AP on IN1 (solid shape): 77.01,36.92 77.01,35.91 77.13,35.8 77.95,35.8 78.21,35.53 78.21,35.08 78.15,35.02 78.15,31.84 77.93,31.61 77.85,31.61 77.76,31.52 77.56,31.52 77.47,31.61 77.47,34.69 77.29,34.87 76.27,34.87 76.13,35.01 76.13,36.97 76.23,37.07 76.87,37.07
PP1800_AP on IN1 (solid shape): 45.78,48.21 48.6,48.21 49.04,48.65 51.62,48.65 51.83,48.45 51.83,48.43 51.91,48.27 52.07,48.19 52.08,48.19 52.36,47.92 52.45,47.73 52.64,47.66 52.76,47.69 52.86,47.77 52.98,47.77 53.41,48.2 55.53,48.2 55.55,48.18 55.65,48.08 55.79,48.04 55.9,48.06 55.99,48.13 59.85,48.13 60.47,47.51 60.47,47.24 60.4,47.18 59.97,47.18 59.54,47.6 53.55,47.6 53.07,47.12 52.34,47.12 51.43,48.03 49.23,48.03 48.89,47.7 45.38,47.7 44.85,48.23 44.85,48.23 44.74,48.33 44.61,48.36 44.54,48.35 44.47,48.33 44.46,48.32 43.92,48.32 43.91,48.33 43.84,48.35 43.77,48.36 43.7,48.35 43.63,48.33 43.62,48.32 43.28,48.32 43.21,48.34 43.16,48.34 43.11,48.34 43.05,48.32 42.79,48.32 42.51,48.04 42.51,46.04 41.6,45.12 41.31,45.12 41.23,45.19 41.23,45.42 42,46.18 42,48.38 42.49,48.87 45.13,48.87
PP1800_AP on IN2 (solid shape): 41.89,39.48 41.89,39.35 41.27,38.73 40.78,38.73 40.63,38.88 40.63,39.38 40.81,39.57 41.81,39.57
PP1800_AP on IN2 (solid shape): 88.96,26.48 88.96,25.92 88.78,25.74 88.62,25.74 88.37,25.49 87.91,25.49 87.66,25.74 87.66,26.6 87.77,26.71 88.73,26.71
PP1800_AP on IN2 (solid shape): outline of 172 points within 77.58,25.41 85.02,32.49
PP1800_AP on IN3 (solid shape): outline of 168 points within 83.98,26.14 89.44,29.47
PP1800_AP on IN3 (solid shape): outline of 476 points within 106.92,30.39 114.33,35.93
PP1800_AP on IN3 (solid shape): outline of 276 points within 34.91,14.61 42.02,23.32
PP1800_AP on IN4 (solid shape): 41.21,15.2 41.21,14.66 41.11,14.56 39.94,14.56 39.81,14.69 39.81,15 40.11,15.3 41.11,15.3
PP1800_AP on IN4 (solid shape): 89.52,26.56 89.52,26.25 89.01,25.74 88.45,25.74 88.44,25.75 87.83,25.75 87.64,25.94 87.64,26.6 87.74,26.7 89.37,26.7
PP1800_AP on IN4 (solid shape): outline of 1094 points within 109.73,32.76 121.47,54.98
PP1800_AP on IN5 (solid shape): outline of 5057 points within 22.59,6.61 113.71,43.82
PP1800_EC on TOP (solid shape): 122.44,59.47 122.44,57.77 122.89,57.31 122.89,56.55 122.79,56.44 121.66,56.44 121.16,56.95 121.16,57.39 121.21,57.44 121.41,57.44 121.57,57.6 121.57,58.48 121.8,58.71 121.8,58.9 121.81,58.9 121.81,59.53 121.88,59.59 122.31,59.59
PP1800_EC on TOP (solid shape): 145.7,26.27 145.7,26.09 144.48,24.87 144.48,24.36 144.38,24.26 144,24.26 143.92,24.34 143.92,24.82 143.7,25.05 142.98,25.05 142.12,24.19 141.79,24.19 141.69,24.29 141.69,24.87 141.87,25.05 142.48,25.05 142.88,25.46 144.41,25.46 145.37,26.42 145.55,26.42
PP1800_EC on TOP (solid shape): 121.6,50.93 121.6,49.38 121.55,49.33 120.95,49.33 120.87,49.41 119.9,49.41 119.63,49.68 119.63,50.84 119.62,50.86 119.62,51.12 119.67,51.18 119.68,51.25 119.68,51.63 119.67,51.69 119.65,51.73 119.63,51.77 119.65,51.8 119.69,51.85 120.68,51.85
PP1800_EC on TOP (solid shape): 131.3,46.23 130.03,44.96 128.28,44.96 128.03,45.21 128.03,46.01 128.13,46.11 129.04,46.11 129.09,46.09 129.14,46.09 129.19,46.09 129.25,46.11 129.65,46.11 130.03,46.49 130.03,46.64 130.12,46.73 130.3,46.73 130.41,46.77 130.45,46.88 130.45,47.26 130.44,47.32 130.41,47.37 130.41,48.19 130.43,48.25 130.43,48.29 130.43,48.59 130.43,48.64 130.41,48.69 130.41,48.77 130.16,49.03 130.16,50.17 130.15,50.18 130.15,50.29 130.14,50.36 130.09,50.42 129.93,50.59 129.88,50.63 129.82,50.65 129.78,50.65 129.78,51.31 130.16,51.7 131.3,51.7
PP1800_EC on BOTTOM (solid shape): 124.93,55.73 127.16,55.73 131.1,51.8 131.1,47.66 130.93,47.49 121.15,47.49 119.72,48.93 119.72,50.43 122.63,53.34 122.63,53.62 122.66,53.65 122.66,55.61 121.98,56.29 121.98,56.65 122.23,56.9 123.76,56.9
PP1800_EC on IN1 (solid shape): 64.07,13.95 64.07,13.87 63.97,13.77 63.64,13.77 63.23,14.18 60.43,14.18 60.33,14.28 60.33,14.48 60.43,14.59 63.43,14.59
PP1800_EC on IN1 (solid shape): outline of 281 points within 125.13,44.84 130.92,50.65
PP1800_EMMC on BOTTOM (solid shape): 103.75,58.12 104.92,58.12 105.4,58.6 106.49,58.6 106.66,58.43 108.41,58.43 109.02,57.83 109.02,56.61 108.87,56.45 107.96,56.45 107.84,56.57 107.04,56.57 106.92,56.45 104.58,56.45 102.52,58.51 102.09,58.51 101.93,58.66 101.93,58.99 102.06,59.12 102.75,59.12
PP1800_H1 on TOP (solid shape): 58.12,22.74 58.12,22.31 57.92,22.1 56.6,22.1 56.45,22.26 56.45,22.76 56.5,22.82 56.7,22.82 56.78,22.84 56.84,22.88 56.88,22.92 57.95,22.92
PP1800_H1 on TOP (solid shape): 52.12,23.48 52.12,22.84 52.16,22.73 52.27,22.69 52.63,22.69 53.32,22.69 53.71,22.69 53.75,22.69 54.03,22.69 54.05,22.7 54.06,22.69 54.29,22.69 54.36,22.61 54.36,22.1 54.21,21.95 52.15,21.95 51.27,22.84 51.27,23.54 51.32,23.6 52.01,23.6
PP1800_H1 on IN2 (solid shape): outline of 155 points within 51.11,16.97 61.35,23.68
PP1800_IT6505_D on TOP (solid shape): 30.89,30.33 30.89,27.9 30.67,27.67 30.13,27.67 29.98,27.82 29.98,30.18 30.21,30.41 30.82,30.41
PP1800_IT6505_D on IN3 (solid shape): outline of 508 points within 24.7,15.28 34.25,28.28
PP1800_LDO on TOP (solid shape): 120.76,55.12 120.76,52.4 120.59,52.24 119.81,52.24 119.68,52.36 119.68,53.08 119.34,53.42 119.34,55.25 119.39,55.3 120.58,55.3
PP1800_LDO on TOP (solid shape): 55.05,23.6 55.05,23.02 54.9,22.87 52.61,22.87 52.49,22.98 52.49,23.52 52.57,23.59 53.09,23.59 53.09,23.6 53.2,23.7 54.95,23.7
PP1800_LDO on TOP (solid shape): 68.74,7.58 68.74,7.38 68.74,7.37 68.74,6.16 68.56,5.98 66.3,5.98 66,6.28 66,7.58 66.2,7.78 68.54,7.78
PP1800_LDO on BOTTOM (solid shape): 101.51,60.69 101.51,54.77 102.6,53.68 117.31,53.68 118.88,55.25 120.35,55.25 120.84,54.77 120.84,54.44 120.8,54.4 120.8,54.04 120.3,53.55 120.3,53.55 117.78,51.03 100.03,51.03 99.35,51.72 99.35,59.04 97.47,60.92 81.64,60.92 75.4,54.67 75.4,49.94 75.01,49.56 73.8,49.56 73.57,49.79 73.57,55.4 76.2,58.03 76.2,58.03 81.33,63.16 99.03,63.16
PP1800_LDO on BOTTOM (solid shape): 57.01,21.57 57.01,20.31 57.39,19.93 57.39,19.21 57.69,18.91 57.69,14.53 57.84,14.38 58.78,14.38 59.19,13.98 60.99,13.98 61.65,13.32 63.43,13.32 64.42,12.33 64.42,9.96 67.29,7.09 67.29,6.74 67.09,6.53 66.15,6.53 63.1,9.58 63.1,11.44 63.13,11.46 63.13,11.48 63.26,11.64 63.31,11.84 63.17,12.17 62.85,12.3 62.66,12.26 62.51,12.15 62.47,12.15 62.45,12.13 61.29,12.13 60.5,12.92 58.77,12.92 58.22,13.48 57.77,13.48 56.7,14.55 56.7,16.26 56.04,16.92 56.04,20.74 54.2,22.57 54.17,22.57 54.14,22.61 53.4,22.61 53.32,22.69 53.32,23.45 53.4,23.53 55.05,23.53
PP1800_LDO on IN5 (solid shape): outline of 594 points within 53.45,22.05 74.53,51.92
PP1800_LPDDR on TOP (solid shape): 86.29,61.42 86.29,57.42 85.84,56.97 85.25,56.97 84.92,57.3 84.92,59.49 84.44,59.97 80.25,59.97 80.04,59.76 80.04,58.55 78.76,57.27 77.57,57.27 77.54,57.24 77.35,57.24 76.65,56.54 76.65,46.25 76.78,46.13 76.78,44.11 76.61,43.95 75.83,43.95 75.72,44.06 75.72,46.84 75.71,46.84 75.71,57.08 77.48,58.85 77.48,60.22 78.51,61.25 78.57,61.25 79.33,62.01 85.71,62.01
PP1800_LPDDR on IN2 (solid shape): 76.72,44.62 76.72,44.08 76.59,43.95 75.83,43.95 75.79,43.99 75.79,45.07 75.94,45.21 76.13,45.21
PP1800_LPDDR on IN2 (solid shape): 83.33,57.78 88.44,57.78 89.33,56.88 89.33,56.37 89.16,56.2 88.91,56.2 88.25,56.86 87.6,56.86 87.52,56.9 87.44,56.92 87.35,56.9 87.27,56.86 82.66,56.86 82,56.2 81.8,56.2 81.44,56.55 81.44,57.32 82.2,58.08 83.03,58.08
PP1800_LPDDR on IN3 (solid shape): 76.58,45.34 77.28,44.63 77.33,44.61 77.42,44.57 77.5,44.51 80.36,41.65 82.03,41.65 82.04,41.66 82.36,41.66 82.4,41.66 82.62,41.66 82.76,41.78 82.81,41.95 82.81,42 82.79,42.06 82.79,42.09 82.8,42.11 82.83,42.14 83.53,42.14 83.86,41.81 83.86,41.34 83.19,40.67 80.08,40.67 77.6,43.15 76.96,43.15 75.88,44.23 75.88,45.12 76.09,45.34 76.52,45.34
PP1800_MIPIBRDG on TOP (solid shape): 72.58,50.12 72.58,49.28 72.45,49.16 71.32,49.16 71.25,49.22 70.11,49.22 70.08,49.25 69.05,49.25 68.36,49.94 68.36,50.4 68.39,50.43 69.07,50.43 69.11,50.48 72.22,50.48
PP1800_MIPIBRDG_A on BOTTOM (solid shape): 66.32,41.62 66.3,41.55 66.3,41.51 66.31,41.46 66.32,41.4 66.33,41.28 66.33,41.15 66.66,40.82 66.66,40.06 66.58,39.99 65.97,39.99 65.86,40.1 65.87,40.16 65.87,40.19 65.87,40.49 65.86,40.57 65.82,40.65 65.82,41.23 65.8,41.25 65.8,41.26 65.76,41.32 65.7,41.35 65.58,41.36 65.52,41.38 65.46,41.38 65.41,41.38 65.35,41.36 65.23,41.36 65.18,41.41 65.18,41.69 65.24,41.74 66.2,41.74
PP1800_MIPIBRDG_A on IN2 (solid shape): 65.54,41.94 65.94,41.94 65.99,41.99 66.33,41.99 66.48,41.84 66.48,40.95 66.35,40.82 65.79,40.82 65.47,41.15 65.38,41.3 65.22,41.39 65.13,41.48 65.13,41.89 65.24,41.99 65.49,41.99
PP1800_MIPIBRDG_A on IN4 (solid shape): 66.19,41.92 66.22,41.92 66.3,41.84 66.3,41.51 66.3,41.47 66.3,41.05 66.2,40.95 65.87,40.95 65.74,41.08 65.74,41.11 65.66,41.3 65.46,41.38 65.44,41.38 65.29,41.54 65.29,41.79 65.51,42.02 66.09,42.02
PP1800_MIPIBRDG_D on BOTTOM (solid shape): 66.83,42.37 66.88,42.35 66.94,42.35 66.99,42.35 67.05,42.37 67.17,42.37 67.7,41.84 67.7,41.18 67.62,41.1 67.14,41.1 67.06,41.18 67.06,41.71 66.91,41.87 66.29,41.87 66.26,41.89 66.02,41.89 65.97,41.94 65.97,42.32 66.02,42.37 66.39,42.37 66.43,42.37 66.71,42.37
PP1800_S3 on TOP (solid shape): 130.67,22.74 130.67,20.96 130.58,20.88 127.32,20.88 127.11,21.09 127.11,22.61 127.36,22.87 130.54,22.87
PP1800_S3 on TOP (solid shape): 54.24,6.88 54.24,6.63 54.08,6.47 53.86,6.47 53.79,6.54 51.57,6.54 51.39,6.37 51.39,6.15 51.29,6.05 50.83,6.05 50.71,6.18 50.71,6.49 51.21,6.99 54.12,6.99
PP1800_S3 on TOP (solid shape): outline of 204 points within 75.75,58.2 116.82,65.74
PP1800_S3 on BOTTOM (solid shape): 101.38,30.16 101.38,27.21 101.63,26.96 102.28,26.96 102.43,26.82 102.43,25.98 102.32,25.87 98.73,25.87 98.43,26.18 98.43,26.21 98.23,26.41 98.23,30.28 98.36,30.41 101.13,30.41
PP1800_S3 on BOTTOM (solid shape): 118.48,60.87 118.48,60.08 118.5,60 118.58,59.94 118.58,58.18 118.25,57.85 117,57.85 116.99,57.86 116.3,57.86 114.66,59.5 114.66,60.19 115.19,60.72 117.08,60.72 117.15,60.78 117.3,60.78 117.4,60.87 118.47,60.87
PP1800_S3 on IN2 (solid shape): outline of 89 points within 113.16,19.97 130.72,26.73
PP1800_S3 on IN3 (solid shape): outline of 287 points within 102.17,23.86 115.31,27.84
PP1800_S3 on IN4 (solid shape): 103.59,26.68 103.59,24.95 103.49,24.85 101.96,24.85 101.76,25.05 101.76,25.66 101.46,25.96 101.46,26.88 101.56,26.98 103.28,26.98
PP1800_S3 on IN5 (solid shape): outline of 1564 points within 113.14,20.58 132.06,63.25
PP1800_SPI_FLASH on TOP (solid shape): 49.84,16.44 49.84,13.75 49.67,13.57 49.09,13.57 48.79,13.26 48.09,13.26 47.96,13.14 47.25,13.14 47.18,13.21 47.18,13.65 47.25,13.72 47.76,13.72 47.94,13.9 47.94,14.36 48.57,14.36 48.57,14.33 48.58,14.28 48.6,14.24 48.6,14.15 48.6,14.12 48.62,14.09 48.64,14.06 48.67,14.04 48.7,14.02 48.73,14.01 48.97,14.01 49,14.02 49.03,14.04 49.06,14.06 49.08,14.09 49.09,14.12 49.1,14.15 49.1,14.24 49.12,14.28 49.13,14.33 49.13,14.38 49.12,14.44 49.1,14.47 49.1,14.56 49.09,14.6 49.08,14.63 49.06,14.66 49.03,14.68 49,14.69 48.97,14.7 48.73,14.7 48.7,14.69 48.67,14.68 48.64,14.66 48.62,14.63 48.6,14.6 48.6,14.56 48.6,14.47 48.58,14.44 48.57,14.38 48.57,14.36 47.94,14.36 47.94,16.54 48.04,16.64 49.64,16.64
PP1800_WLAN on BOTTOM (solid shape): outline of 220 points within 118.83,53.6 135.34,60.87
PP3000_EMMC on TOP (solid shape): 115.5,50.43 115.5,49.14 115.42,49.06 114.35,49.06 114.2,49.21 114.2,49.57 114.24,49.57 114.34,49.62 114.39,49.72 114.39,50.54 114.39,50.54 114.43,50.59 115.34,50.59
PP3000_EMMC on TOP (solid shape): 111.51,40.27 111.51,39.83 111.2,39.83 111.12,39.81 111.06,39.77 110.65,39.36 109.85,39.36 109.69,39.53 109.56,39.53 109.49,39.6 109.49,39.65 109.62,39.78 110.4,39.78 110.49,39.88 110.56,39.86 110.6,39.86 110.8,39.94 110.88,40.13 110.88,40.15 110.9,40.23 110.98,40.26 111.1,40.26 111.17,40.27 111.25,40.29 111.49,40.29
PP3000_EMMC on IN1 (solid shape): 111.63,41.7 111.7,41.7 111.84,41.56 111.87,41.53 111.87,41.48 111.64,41.25 111.64,40.44 111.6,40.39 111.58,40.37 111.53,40.29 111.52,40.2 111.52,40.18 111.48,40.14 111.49,40.14 111.49,40.01 111.11,40.01 110.98,40.14 110.98,40.86 111.1,40.98 111.13,41.15 111.12,41.28 111.06,41.39 111.38,41.71 111.62,41.71
PP3000_EMMC_R on TOP (solid shape): 109.76,60.52 109.76,54.55 110.67,53.63 111.46,53.63 111.48,53.61 111.98,53.61 114.05,51.55 114.05,50.63 114.02,50.59 114.01,50.54 114.01,49.79 113.97,49.75 113.13,49.75 113.06,49.82 113.06,50.51 112.91,50.66 112.37,50.66 112.07,50.97 110.16,50.97 108.21,52.92 108.21,60.49 108.39,60.67 109.6,60.67
PP3000_EMMC_R on BOTTOM (solid shape): 109.02,60.45 109.02,60.09 108.94,60.01 104.3,60.01 104.07,59.78 104.07,59.06 103.97,58.96 103.97,58.33 103.76,58.33 103.56,58.54 103.56,60.21 104.09,60.75 108.72,60.75
PP3000_EMMC_R on IN2 (solid shape): 106.03,60.56 106.03,60.25 105.9,60.13 105.89,60.12 105.78,60.05 105.71,59.94 105.7,59.93 105.57,59.8 105.37,59.8 105.14,60.03 105.14,60.48 105.17,60.52 105.17,60.87 105.27,60.97 105.61,60.97
PP3000_EMMC_R on IN3 (solid shape): 106.2,60.42 106.2,60.11 106.1,60.04 106.04,59.98 105.97,59.92 105.92,59.83 105.91,59.82 105.08,58.99 105.02,58.99 104.95,58.93 104.85,58.9 104.78,58.97 104.63,59.18 104.39,59.27 104.1,59.15 103.98,58.86 104,58.73 104.07,58.61 104.03,58.56 103.97,58.54 103.66,58.54 103.46,58.74 103.46,59.12 104.51,60.17 104.62,60.11 104.75,60.09 105.04,60.2 105.16,60.49 105.16,60.54 105.15,60.59 105.17,60.67 105.25,60.71 105.91,60.71
PP3300_ALW on TOP (solid shape): 36.3,39.48 36.3,37.75 36.08,37.52 34.4,37.52 34.1,37.83 34.1,38.89 34.83,39.63 36.15,39.63
PP3300_ALW on TOP (solid shape): 18.41,34.94 18.41,33.53 18.31,33.43 17.79,33.43 17.66,33.56 17.66,34.27 17.53,34.4 16.32,34.4 16.24,34.47 16.24,35.19 16.62,35.57 17.79,35.57
PP3300_ALW on TOP (solid shape): 17.2,12.72 19.11,12.72 19.33,12.5 19.33,12.02 19.26,11.94 16.72,11.94 16.57,12.1 16.57,12.1 16.3,12.36 16.3,12.78 16.16,12.92 16.16,13.17 16.35,13.36 16.57,13.36
PP3300_ALW on TOP (solid shape): 41.25,41.43 41.3,41.38 41.37,41.37 41.71,41.37 41.77,41.31 41.77,40.85 41.61,40.7 41.03,40.7 40.95,40.62 40.95,40.32 40.93,40.29 40.44,40.29 39.86,40.87 39.86,41.36 39.94,41.43
PP3300_ALW on TOP (solid shape): 19.85,25.69 19.69,25.53 19.46,25.53 16.49,22.56 15.39,22.56 14.99,22.96 14.12,22.96 14.05,23.02 14.05,23.7 14.14,23.79 15.25,23.79 16.92,25.45 16.92,25.5 17.03,25.61 17.56,25.61 17.88,25.93 18.48,25.93 18.65,25.86 18.83,25.93 19.07,25.93 19.27,26.12 19.85,26.12
