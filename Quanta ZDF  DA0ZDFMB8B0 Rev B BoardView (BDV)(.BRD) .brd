# Allegro board Quanta ZDF  DA0ZDFMB8B0 Rev B BoardView (BDV)(.BRD) .brd (continued)
## Nets (continued)
N61762994: C10645.1 C10694.2 R90667.1 U6570.10(VOUT)
N61763032: R90666.1 U6570.9
N61763034: C10645.2 R90666.2
N61763068: PC133.1 U6570.11
N61763881: C10489.1 C10632.1 C10695.1 C10696.1 R90674.2 R91266.1 U6571.5
N61763949: PR263.2 U6571.1
N61763953: C10633.1 PR263.1
N61763986: C10633.2 PL2704.1 PR264.1 U6571.2 U6571.3
N61763990: PC134.1 PR264.2
N61764017: C10437.1 C10634.1 C10697.1 C10698.1 NC294.1 PC135.1 PL2704.2 R90675.2 R90678.1
N61764234: C10643.1 R90675.1 U6571.10(VOUT)
N61764266: R90677.1 U6571.12
N61764268: C10643.2 R90677.2
N61764315: PC137.1 U6571.9
N61765555: R91266.2 R91276.2 U6571.6
N61767628: Q797.2 R91267.2 R91268.2
N61769349: Q798.3 R91270.1
N61796219: C10718.1 PU1.3 R91306.1
N61796431: Q799.3 Q799.6
N61796434: Q800.3 Q800.6
N61812172: R91273.2 R91274.2 R91275.1 R91276.1
N61830685: Q802.2 Q803.3 R91278.1
N61830695: C10709.2 Q803.2 R91277.2
N62092946: Q804.3 R91308.1
N62093576: Q805.2 Q806.3 R91309.1
N62093590: Q805.3 R91310.2
N62183299: Q807.1 Q808.1 R91312.1
N62372459: TP9184.1 U6582.C1
N62373890: C10716.2 U6582.A2
N62374623: R90603.2 U6533.B3
N62374627: R90604.2 U6533.C3
N62374648: R90633.2 U6533.B2

Pads without a net: CON7102 6 7 10 29 30; CON9105 6 7 10 29 30; HOLE17 1; HOLE18 1; J15 8 26 30 34; J20 4 5; J24 2; NOREF 1; NOREF#2 1; NOREF#3 1; NOREF#4 1; NOREF#5 1; NOREF#6 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; NOREF#10 1; NOREF#11 1; NOREF#13 1; NOREF#14 1; NOREF#15 1; NOREF#16 1; NOREF#17 1; NOREF#18 1; NOREF#19 1; NOREF#21 1; NOREF#23 1; NOREF#24 1; NOREF#25 1; NOREF#26 1; NOREF#27 1; NOREF#28 1; NOREF#29 1; NOREF#30 1; NOREF#31 1; NOREF#32 1; NOREF#33 1; NOREF#34 1; PU1 4; U1 1 2 3 5 7 8 9 10 46 47 53 54 57 62 65 66 67 68 77 84 86 87 88; U5 A2 A3 A4 A5 K2 K3 K4 K5; U18 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U23 1; U93 26 27 28 29; U124 C3 C4 C5 C7 D7 E3 E7 F3 F7 G3 G5 G6 G7 H2 H3; U1001 A1 A22 A24 A27 AA4 AC2 AC6 AD5 AD6 AE5 AE6 AE7 AE11 AE12 AE13 AE20 AE21 AE22 AE23 AF6 AF7 AF11 AF12 AF13 AF14 AF16 AF17 AF20 AF21 AF23 AF24 AG4 AG5 AG6 AG7 AG11 AG12 AG13 AG14 AG16 AG17 AG20 AH3 AH4 AH5 AH6 AH7 AH10 AH11 AH12 AH13 AH14 AH16 AH17 AH22 AJ1 AJ4 AJ5 AJ7 AJ8 AJ10 AJ12 AJ13 AJ15 AJ16 AJ22 AJ24 AJ26 AJ27 B1 B22 B24 C1 D1 D2 E22 F1 F2 F23 G1 G2 G24 G25 H27 J1 J2 J6 J7 J14 J15 J24 J25 J27 K4 K5 L4 L5 N22 V22 Y12 Y13; U1007 1 2 3 7 8 9 10 11 12 14 15 16 18 19 21 22 24 25 31 33 34 36 37 39 40 43 44 66 67 69 70; U2001 A1 A4 A16 D5 G5 G6 H6 J6 J13 N4 P5 R1 R16; U6404 10 11; U6524 8 9 10 13; U6525 8 9 10 13; U6526 8 9 10 13; U6530 8 9 10 13; U6546 20; U6553 3; U6554 3; U6555 6; U6558 A2; U6559 35 36; U6563 3 4 20 21; U6572 3; U6573 3; U6576 3; U6577 C1; U6578 A1 A5 A6 A7 A8 B1 B3 B4 E1 F1 F2 F6 F7 G2 G3 G4 G5 G6 G7 H2 H3; UD1 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 K5 K8 N5 N8

## Via types
v1: diameter 0.25, hole 0.102, TOP to IN1, 2518 vias
v2: diameter 0.25, hole 0.102, IN1 to IN2, 2232 vias
v3: diameter 0.406, hole 0.203, IN2 to IN4, 1850 vias
v4: diameter 0.25, hole 0.102, IN4 to IN5, 1393 vias
v5: diameter 0.25, hole 0.102, IN5 to BOTTOM, 1262 vias
v6: diameter 0.508, hole 0.254, TOP to BOTTOM, 576 vias
v7: diameter 0.22, hole 0.102, TOP to IN1, 698 vias
v8: diameter 0.22, hole 0.102, IN1 to IN2, 498 vias
v9: diameter 0.22, hole 0.102, IN4 to IN5, 105 vias
v10: diameter 0.22, hole 0.102, IN5 to BOTTOM, 147 vias
v11: diameter 0.61, hole 0.356, TOP to BOTTOM, 1 via

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3V3_PCSCL: length 2.5
  BOTTOM w0.089: Q3.1 25.25,17.54 25.41,17.38 25.41,16.79 R90154.1 25.01,15.92 25,15.91 R12.1
3V3_PCSDA: length 2.7
  BOTTOM w0.089: R13.1 25.76,16.14 R90155.1 25.66,16.74 25.66,17.47 25.75,17.56 Q4.1
AVDD18_SOC: length 14.5
  TOP w0.15: 88.32,32.42 88.32,32.85 U1001.AH21
  TOP w0.178: 88.32,32.42 88.32,32.09
  TOP w0.254: 87.51,32.37 87.79,32.65 87.79,33.12 U1001.AH19
  TOP w0.305: v2(86.53,32.19) 86.78,32.19 86.96,32.37 87.51,32.37 ; v2(87.31,31.43) 87.79,31.43 C1004.1 87.94,31.4 88.32,31.78 88.32,32.09 ; v2(91.03,41.96) 91.2,41.96 91.74,42.5 92.31,42.5 92.54,42.73 92.82,42.73 92.82,42.73
  IN2 w0.203: v8(83.03,35.17) 83.03,34.94 v3(83.24,34.73) ; v2(87.31,31.43) 87.31,31.91 v3(87.23,31.98)
  IN2 w0.254: v3(86.29,31.97) 86.31,31.97 v2(86.53,32.19) ; v2(85.43,35.56) 85.46,35.56 85.6,35.42 v3(85.76,35.42)
  IN4 w0.178: v5(99.08,32.57) 100.41,31.23 v4(101.39,31.23)
  IN4 w0.254: v3(85.76,35.42) 85.64,35.42 v5(85.46,35.25)
  IN5 w0.178: v5(101.86,30.96) 101.66,30.96 v4(101.39,31.23)
  BOTTOM w0.178: SH2101.1 98.27,33.37 v5(99.08,32.57)
  BOTTOM w0.2: C1011.2 85.77,35.25 v5(85.46,35.25)
  vias: v1(85.83,30.23) v1(86.09,30.49) v1(86.09,30.23) v1(91.05,45.01) v1(93.4,42.7) v2(85.83,30.23) v2(86.09,30.49) v2(86.09,30.23) v2(91.05,45.01) v2(93.4,42.7) v3(79.97,44.13) v3(80.27,43.85) v3(85.96,30.79) v3(93.02,42.28) v3(92.97,41.87) v3(93.61,47.61) v4(86.62,32.31) v4(86.62,31.86) v4(86.75,32.09) v4(86.88,32.31) v4(86.88,31.86) v4(87.13,32.31) v4(93.84,46.93) v4(93.84,46.67) v4(94.09,46.93) v4(94.09,46.67) v5(84.56,30.59) v5(84.79,30.44) v5(85.02,30.59) v5(85,30.28) v5(85.22,30.44) v5(85.43,30.59) v5(85.43,30.28) v5(85.66,30.44) v5(86.62,32.31) v5(86.62,31.86) v5(86.75,32.09) v5(86.83,31.6) v5(86.88,32.31) v5(86.88,31.86) v5(87.13,32.31) v5(87.08,31.63) v5(87.31,31.53) v5(87.36,31.92) v5(87.51,31.71) v5(89.8,39.97) v5(89.8,39.71) v5(89.8,39.46) v5(90.05,39.84) v5(90.99,34.46) v5(91.24,34.46) v5(91.5,34.46) v5(91.75,34.46) v5(93.84,46.93) v5(93.84,46.67) v5(94.09,46.93) v5(94.09,46.67) v7(81.03,43.56) v7(89.43,42.76) v7(89.43,41.16) v8(80.65,43.78) v8(80.83,43.93) v8(89.43,42.76) v8(89.43,41.16) v9(80.48,44.34) v9(80.48,44.11) v9(80.68,44.21) v9(80.77,43.92) v10(80.48,44.34) v10(80.48,44.11) v10(80.68,44.21) v10(80.77,43.92)
AVSS28_AUD: length 134
  TOP w0.305: SH6204.2 10.66,23.16 11.26,22.56 11.84,22.56 12.1,22.31 14.38,22.31 v6(14.69,22)
  IN1 w0.06: 107.52,36.56 107.41,36.67 107.41,37.03 107.22,37.22 v7(107.22,37.25)
  IN1 w0.152: 107.52,36.56 107.52,36.15 107.5,36.12
  IN1 w0.305: v1(108.13,30.32) 108.13,30.52 107.73,30.92 v2(107.73,31.73) 107.35,32.11 107.35,34.7 107.5,34.85 107.5,36.12
  IN2 w0.305: v2(107.73,31.73) 107.96,31.96 108.14,31.96 108.39,32.22 108.39,32.77 108.31,32.85 v3(108.31,33.44)
  IN3 w0.305: v3(29.85,25.56) 29.62,25.33 29.62,22.05 27.9,20.33 27.9,18.93 26.02,17.05 24.82,17.05 24.62,17.25 23.54,17.25 23.06,16.77 21.95,16.77 21.34,17.38 21.34,18.5 19.97,19.87 16.82,19.87 v6(14.69,22)
  IN4 w0.305: v5(108.31,33.85) v3(108.31,33.44)
  IN5 w0.305: v5(108.31,33.85) 108.31,33.85 108.02,33.85 106.54,32.37 106.54,28.3 105.9,27.67 105.49,27.67 102.24,24.42 63.43,24.42 61.22,22.21 60.92,22.21 60.33,21.62 58.1,21.62 57.97,21.49 54.44,21.49 v5(53.83,20.89)
  BOTTOM w0.305: v5(30.36,25.56) v5(29.32,25.56) 29.32,26.24 29.5,26.42 29.5,28.25 30.21,28.96 34.15,28.96 34.4,28.71 35.95,28.71 36.33,28.33 36.33,26.88 38.77,24.44 39.48,24.44 41.61,22.31 47.61,22.31 47.92,22 49.74,22 50.48,21.27 51.8,21.27 52.18,20.89 v5(53.83,20.89)
DVDD18_DIG: length 1.2
  IN2 w0.102: v3(107.6,38.48) 107.57,38.45 107.34,38.45 107.27,38.51 v8(107.25,38.51)
  IN4 w0.102: v5(107.6,38.82) 107.6,38.81 v3(107.6,38.48)
  BOTTOM w0.102: C2141.1 107.7,38.72 v5(107.6,38.82)
DVDD_CORE: length 28.5
  TOP w0.15: v7(85.03,37.96) v7(84.64,38.36) ; v7(83.03,35.56) 83.31,35.28 83.31,35.04 U1001.AD7 ; 87.83,38.76 87.03,39.56 v8(86.64,39.56) ; 87.83,38.76 88.24,39.16 ; 87.83,38.76 87.54,38.46 87.54,38.26 87.83,37.96 v8(87.83,37.56) ; 88.24,39.16 88.68,39.6 ; 88.24,39.16 U1001.P21 ; v7(86.24,36.76) v7(86.64,36.36)
  TOP w0.2: v7(83.03,38.36) v7(83.43,38.36) v7(83.43,37.96) v7(83.03,37.96) v7(83.03,38.36) ; v7(83.03,38.36) v7(83.03,38.76) ; U1001.U21 88.56,37.56 88.32,37.33 88.32,37.25 v8(88.24,37.16) ; U1001.AC22 v7(89.03,35.56) ; v8(88.24,37.16) 87.84,37.56 v8(87.83,37.56) ; v8(88.24,37.16) v8(87.83,36.76) v7(88.24,36.36) ; U1001.H21 88.68,41.12 88.68,39.6 ; U1001.J16 v8(86.64,40.36) v8(86.24,39.96) v8(86.64,39.56) v8(86.24,39.16) v8(86.64,38.76) v1(86.24,38.36) v7(86.64,37.96) v7(86.24,37.56) v7(86.64,37.16) v7(86.24,36.76) ; U1001.V27 92.07,37.16 v2(92.08,37.17) 92.08,36.86 92.19,36.76 C6701.1 ; v8(85.03,40.36) v8(84.64,39.96) v8(85.03,39.56) v8(84.64,39.16) v7(85.03,38.76) v7(84.64,38.36)
  IN1 w0.15: v7(83.03,35.56) 83.32,35.85 83.32,36.88 83.03,37.17 v7(83.03,37.96)
  IN1 w0.2: v7(89.03,35.56) v7(88.24,36.36)
  IN2 w0.254: v3(90.66,36.84) 90.76,36.94 91.85,36.94 v2(92.08,37.17)
  vias: v1(93.74,31.95) v1(93.86,32.65) v1(94.01,31.98) v1(94.12,32.62) v1(94.29,31.97) v1(94.37,32.62) v1(94.57,31.95) v1(94.84,32.06) v1(98.86,43.83) v1(98.86,43.42) v1(99.09,43.95) v1(99.08,43.68) v1(99.12,43.42) v1(99.22,44.18) v1(99.35,43.95) v1(99.35,43.68) v1(99.37,43.42) v1(99.47,44.23) v1(99.6,44.46) v1(99.7,44.69) v1(99.78,44.29) v1(99.94,44.87) v1(99.92,44.52) v1(99.96,43.35) v1(100.13,44.69) v1(100.19,44.41) v1(100.21,43.37) v1(100.3,44.9) v1(100.44,44.23) v1(100.49,44.69) v1(100.68,44.9) v1(100.7,44.52) v2(93.74,31.95) v2(93.86,32.65) v2(94.01,31.98) v2(94.12,32.62) v2(94.29,31.97) v2(94.37,32.62) v2(94.57,31.95) v2(94.84,32.06) v2(98.86,43.83) v2(98.86,43.42) v2(99.09,43.95) v2(99.08,43.68) v2(99.12,43.42) v2(99.22,44.18) v2(99.35,43.95) v2(99.35,43.68) v2(99.37,43.42) v2(99.47,44.23) v2(99.6,44.46) v2(99.7,44.69) v2(99.78,44.29) v2(99.94,44.87) v2(99.92,44.52) v2(99.96,43.35) v2(100.13,44.69) v2(100.19,44.41) v2(100.21,43.37) v2(100.3,44.9) v2(100.44,44.23) v2(100.49,44.69) v2(100.68,44.9) v2(100.7,44.52) v3(84.68,40.31) v3(84.69,39.61) v3(84.97,39.94) v3(84.97,39.22) v3(86.29,39.59) v3(86.29,38.81) v3(86.59,39.96) v3(86.57,39.23) v3(87.9,37.2) v3(88.2,36.82) v3(93.77,32.3) v3(94.19,32.3) v3(94.6,32.29) v3(99.68,43.95) v3(99.68,43.55) v3(100.08,44.08) v3(100.08,43.68) v3(100.77,44.13) v3(100.77,43.73) v3(100.8,43.32) v4(86.23,39.14) v4(90.66,37.17) v4(90.91,37.25) v4(99.96,43.35) v4(99.98,43.09) v4(100.21,43.27) v4(100.24,43.02) v4(100.41,44.29) v4(100.41,44.03) v4(100.41,43.78) v4(100.41,43.52) v4(100.46,43.27) v4(100.49,43.02) v5(84.1,40.63) v5(84.18,39.71) v5(84.36,39.54) v5(86.23,39.14) v5(89.47,37.45) v5(89.47,37.2) v5(89.49,36.61) v5(89.72,37.45) v5(89.72,37.2) v5(89.72,36.84) v5(90.33,36.89) v5(90.38,36.63) v5(90.66,37.17) v5(90.91,37.25) v5(99.96,43.35) v5(99.98,43.09) v5(100.21,43.27) v5(100.24,43.02) v5(100.41,44.29) v5(100.41,44.03) v5(100.41,43.78) v5(100.41,43.52) v5(100.46,43.27) v5(100.49,43.02) v7(84.64,40.76) v8(84.64,40.76) v9(84.43,40.66) v9(84.64,39.95) v9(84.7,40.67) v9(85.03,40.56) v9(85.02,39.59) v9(85.05,40.28) v9(86.02,39.86) v9(86.22,39.95) v9(86.15,38.51) v9(88.27,37.16) v9(88.5,37.14) v9(88.48,36.65) v9(88.63,36.82) v9(88.73,37.17) v10(84.43,40.66) v10(84.64,39.95) v10(84.7,40.67) v10(85.03,40.56) v10(85.02,39.59) v10(85.05,40.28) v10(85.18,39.18) v10(85.35,40.05) v10(85.41,38.92) v10(85.47,39.6) v10(85.55,39.16) v10(85.64,37.9) v10(85.81,39.51) v10(85.94,38.86) v10(85.86,38.51) v10(85.92,37.44) v10(86.02,39.86) v10(86.22,39.95) v10(86.15,38.51) v10(86.27,37.66) v10(86.45,37.17) v10(86.64,37.41) v10(86.75,36.87) v10(86.91,37.2) v10(87.26,36.99) v10(87.54,37.18) v10(87.81,36.93) v10(87.9,37.24) v10(88.23,36.51) v10(88.27,37.16) v10(88.44,36.42) v10(88.5,37.14) v10(88.48,36.65) v10(88.63,36.82) v10(88.73,37.17) v10(88.66,36.43)
DVDD_CORE_PMIC_FB: length 27.5
  IN2 w0.076: v8(104.83,41.65) 104.8,41.65 104.53,41.92 103.74,41.92 v3(103.72,41.94)
  IN4 w0.076: v3(103.72,41.94) 103.74,41.92 104.07,41.92 104.43,41.56 104.43,40.87 101.48,37.92 97.78,37.92 95.4,40.29 92.46,40.29 92.31,40.44 91.85,40.44 90.6,39.2 90.34,39.2 89.95,38.8 89.95,36.75 89.29,36.09 87.82,36.09 86.75,37.16 86.75,37.36 86.51,37.6 86.51,37.74 86.29,37.95 v5(86.29,38.04)
  BOTTOM w0.076: SH1806.2 86.37,38.11 v5(86.29,38.04)
DVDD_CORE_PMIC_GND: length 25.4
  IN2 w0.076: v3(104.02,41.41) 104.04,41.41 104.28,41.65 v8(104.42,41.65)
  IN4 w0.076: v3(104.02,41.41) 104.12,41.41 104.25,41.28 104.25,40.9 101.42,38.07 97.84,38.07 95.47,40.44 92.53,40.44 92.38,40.6 91.78,40.6 90.54,39.35 90.25,39.35 89.8,38.89 89.8,36.82 89.22,36.24 87.88,36.24 86.9,37.22 86.9,37.42 86.66,37.66 v5(86.66,37.94)
  BOTTOM w0.076: v5(86.66,37.94) 86.6,38 SH1805.1
DVDD_GPU: length 1.1
  TOP w0.2: v8(88.24,38.76) v8(87.83,38.36) v7(88.24,37.96)
  vias: v1(98.9,41.95) v1(98.9,41.7) v1(98.9,41.44) v1(99.15,41.95) v1(99.15,41.7) v1(99.15,41.44) v1(99.42,41.97) v1(99.41,41.71) v1(99.42,41.44) v1(99.68,41.97) v1(99.66,41.71) v1(99.68,41.44) v1(99.93,42.23) v1(99.93,41.97) v1(99.92,41.7) v1(99.93,41.44) v2(88.01,39.74) v2(88.63,39.99) v2(98.9,41.95) v2(98.9,41.7) v2(98.9,41.44) v2(99.15,41.95) v2(99.15,41.7) v2(99.15,41.44) v2(99.42,41.97) v2(99.41,41.71) v2(99.42,41.44) v2(99.68,41.97) v2(99.66,41.71) v2(99.68,41.44) v2(99.93,42.23) v2(99.93,41.97) v2(99.92,41.7) v2(99.93,41.44) v3(87.84,38.72) v3(88.12,40.37) v3(88.25,39.1) v3(88.27,39.97) v3(88.53,40.5) v3(88.57,39.65) v3(94.56,45.83) v3(94.57,45.42) v3(94.97,45.83) v3(94.98,45.42) v3(95.37,45.83) v3(98.59,42.58) v3(98.86,42.28) v3(98.97,42.73) v3(99.27,42.28) v3(99.37,42.73) v4(88.17,45.83) v4(88.17,45.58) v4(88.43,45.83) v4(88.43,45.58) v4(88.66,39.22) v4(89.42,45.89) v4(89.42,45.63) v4(89.67,45.89) v4(89.67,45.63) v4(91.68,45.89) v4(91.68,45.63) v4(91.93,45.89) v4(91.93,45.63) v4(95.26,47.31) v4(95.26,47.05) v4(95.26,46.8) v4(95.26,46.52) v4(95.51,47.31) v4(95.51,47.05) v4(95.51,46.8) v4(95.51,46.52) v4(95.77,47.31) v4(95.77,47.05) v4(95.77,46.8) v4(95.77,46.52) v4(97.7,43.32) v4(97.7,43.07) v4(97.7,42.81) v4(97.95,43.32) v4(97.95,43.07) v4(97.95,42.81) v4(98.2,43.32) v4(98.2,43.07) v4(98.2,42.81) v4(98.51,43.45) v4(98.51,43.19) v4(98.51,42.93) v5(88.17,45.83) v5(88.17,45.58) v5(88.43,45.83) v5(88.43,45.58) v5(88.66,39.22) v5(89.42,45.89) v5(89.42,45.63) v5(89.67,45.89) v5(89.67,45.63) v5(91.68,45.89) v5(91.68,45.63) v5(91.93,45.89) v5(91.93,45.63) v7(87.83,40.76) v7(87.81,40.27) v7(87.83,39.96) v7(87.83,39.56) v7(87.83,39.16) v7(88.24,40.76) v7(88.24,39.56) v8(87.83,40.76) v8(87.81,40.27) v8(87.83,39.96) v8(87.83,39.56) v8(87.83,39.16) v8(88.24,40.76) v8(88.24,39.56) v9(87.94,40.93) v9(87.89,40.14) v9(87.9,39.83) v9(87.94,39.56) v9(87.9,39.07) v9(88.24,40.88) v9(88.2,39.58) v9(88.63,39.97) v10(87.94,40.93) v10(87.89,40.14) v10(87.9,39.83) v10(87.94,39.56) v10(87.9,39.07) v10(88.24,40.88) v10(88.2,39.58) v10(88.63,39.97)
DVDD_GPU_PMIC_FB: length 29.6
  IN2 w0.076: v8(105.22,40.85) 104.95,40.85 104.68,40.58 103.72,40.58 102.4,41.9 102.18,41.9 101.75,42.33 101.75,42.5 v3(101.58,42.67)
  IN4 w0.076: v3(101.58,42.67) 101.78,42.67 102.06,42.95 102.06,47.09 101.49,47.66 98.13,47.66 97.93,47.86 97.13,47.86 96.81,47.54 96.81,46.67 96.15,46.01 96.15,45.5 95.22,44.58 94.55,44.58 94.15,44.18 94.15,41.59 93.72,41.16 91.92,41.16 90.69,39.93 89.49,39.93 89.26,40.16 89.26,40.45 89.34,40.53 v5(89.34,40.62)
  BOTTOM w0.076: SH1802.1 88.73,40.4 88.89,40.56 89.28,40.56 v5(89.34,40.62)
DVDD_GPU_PMIC_GND: length 28
  IN2 w0.076: v3(102.16,42.48) 102.07,42.39 102.07,42.22 102.25,42.05 102.46,42.05 103.78,40.73 104.62,40.73 104.83,40.94 v8(104.83,41.25)
  IN4 w0.076: v3(102.16,42.48) 102.21,42.52 102.21,47.16 101.55,47.82 98.2,47.82 98,48.02 97.07,48.02 96.65,47.6 96.65,46.73 95.99,46.07 95.99,45.57 95.16,44.73 94.48,44.73 94,44.25 94,41.66 93.66,41.31 91.86,41.31 90.63,40.09 89.79,40.09 v5(89.6,40.28)
  BOTTOM w0.076: SH1801.2 89.1,40.28 v5(89.6,40.28)
DVDD_PROC_B: length 4
  TOP w0.2: v8(84.24,35.16) v8(84.24,34.76) v8(83.83,34.76) v8(83.83,35.16) ; v8(84.24,35.16) v8(83.83,35.16) ; v8(84.24,35.16) v8(84.64,35.16) ; v8(84.24,35.16) v7(84.24,35.96) v8(83.83,35.96) v8(83.83,35.56) v8(83.83,35.16)
  vias: v1(80.8,31.13) v1(80.8,30.88) v1(80.8,30.62) v1(81.05,31.13) v1(81.05,30.88) v1(81.05,30.62) v1(81.31,31.13) v1(81.31,30.88) v1(81.31,30.62) v1(81.56,31.13) v1(81.56,30.88) v1(81.56,30.62) v1(81.84,31.56) v1(81.84,31.31) v1(82.1,31.56) v1(82.1,31.31) v1(82.35,31.56) v1(82.35,31.31) v1(82.6,31.56) v1(82.6,31.31) v1(82.88,31.38) v1(83.26,31.54) v1(83.26,31.28) v1(83.26,31.03) v1(99.02,37.19) v1(99.02,36.92) v1(99.02,36.67) v1(99.02,36.41) v1(98.99,36.16) v1(98.99,35.9) v1(99.25,36.18) v1(99.25,35.9) v1(99.3,37.22) v1(99.27,36.94) v1(99.27,36.69) v1(99.27,36.44) v1(99.53,36.94) v1(99.53,36.69) v1(99.53,36.44) v1(99.5,36.18) v1(99.53,35.9) v1(99.57,37.2) v1(99.83,37.2) v1(99.78,36.94) v1(99.78,36.69) v1(99.78,36.44) v1(99.75,36.18) v1(99.78,35.9) v1(100.01,36.18) v1(100.03,35.9) v2(80.8,31.13) v2(80.8,30.88) v2(80.8,30.62) v2(81.05,31.13) v2(81.05,30.88) v2(81.05,30.62) v2(81.31,31.13) v2(81.31,30.88) v2(81.31,30.62) v2(81.56,31.13) v2(81.56,30.88) v2(81.56,30.62) v2(81.84,31.56) v2(81.84,31.31) v2(82.1,31.56) v2(82.1,31.31) v2(82.35,31.56) v2(82.35,31.31) v2(82.6,31.56) v2(82.6,31.31) v2(82.88,31.38) v2(83.26,31.54) v2(83.26,31.28) v2(83.26,31.03) v2(99.02,37.19) v2(99.02,36.92) v2(99.02,36.67) v2(99.02,36.41) v2(98.99,36.16) v2(98.99,35.9) v2(99.25,36.18) v2(99.25,35.9) v2(99.3,37.22) v2(99.27,36.94) v2(99.27,36.69) v2(99.27,36.44) v2(99.53,36.94) v2(99.53,36.69) v2(99.53,36.44) v2(99.5,36.18) v2(99.53,35.9) v2(99.57,37.2) v2(99.83,37.2) v2(99.78,36.94) v2(99.78,36.69) v2(99.78,36.44) v2(99.75,36.18) v2(99.78,35.9) v2(100.01,36.18) v2(100.03,35.9) v3(80.72,31.87) v3(80.7,31.46) v3(81.13,31.87) v3(81.11,31.46) v3(81.54,31.87) v3(81.51,31.46) v3(81.72,26.1) v3(81.72,25.69) v3(81.97,31.92) v3(82.17,26.15) v3(82.17,25.75) v3(82.4,32.32) v3(82.38,31.92) v3(82.63,26.1) v3(82.63,25.69) v3(82.81,32.32) v3(82.78,31.87) v3(83.14,32.07) v3(83.52,35.87) v3(83.56,35.4) v3(84.18,35.96) v3(84.17,35.49) v3(84.64,35.96) v3(84.62,35.51) v3(99.88,27.57) v3(99.9,27.12) v3(100.28,27.57) v3(100.31,27.12) v3(100.69,27.57) v3(100.71,27.12) v4(81.28,25.97) v4(81.28,25.72) v4(81.28,25.47) v4(81.28,25.21) v4(81.54,25.16) v4(81.69,25.36) v4(81.84,25.16) v4(81.99,25.36) v4(82.15,25.16) v4(82.3,25.36) v4(82.45,25.16) v4(82.6,25.36) v4(83.17,35.17) v4(99.42,26.2) v4(99.42,25.9) v4(99.72,26.2) v4(99.72,25.9) v4(100.03,26.2) v4(100.03,25.9) v4(100.33,26.2) v4(100.33,25.9) v4(100.49,26.5) v4(100.64,26.2) v4(100.64,25.9) v4(100.79,26.51) v5(83.14,36.14) v5(83.17,35.17) v9(82.78,31.54) v9(83.01,31.51) v9(83.13,35.89) v9(83.13,35.47) v9(83.11,31.74) v9(83.24,31.49) v9(83.34,31.69) v9(83.42,32.22) v9(83.42,31.92) v9(83.47,31.49) v9(83.65,31.92) v9(83.57,31.69) v9(83.7,31.49) v9(83.83,36.03) v9(83.83,35.62) v9(83.8,31.74) v10(82.78,31.54) v10(83.01,31.51) v10(83.13,35.89) v10(83.13,35.47) v10(83.11,31.74) v10(83.24,31.49) v10(83.34,31.69) v10(83.42,32.22) v10(83.42,31.92) v10(83.47,31.49) v10(83.65,31.92) v10(83.57,31.69) v10(83.73,35.1) v10(83.7,31.49) v10(83.83,36.03) v10(83.83,35.62) v10(83.8,31.74) v10(84.41,35.1) v10(84.97,35.89) v10(84.97,35.36)
DVDD_PROC_B_PMIC_FB: length 34.9
  TOP w0.076: U2001.D6 105.08,37.8 v8(104.9,37.8)
  IN2 w0.076: v3(103.64,37.73) 103.97,37.39 104.5,37.39 v8(104.9,37.8)
  IN4 w0.076: v4(103.89,37.42) 103.69,37.62 103.69,37.67 v3(103.64,37.73)
  IN5 w0.076: v4(103.89,37.42) 104.02,37.3 104.02,37.15 103.74,36.87 103.74,35.97 103.92,35.79 103.92,32.07 101.63,29.78 84.65,29.78 83.48,30.95 82.48,30.95 82.27,31.16 82.27,31.89 82.94,32.56 82.94,34.31 v10(83.03,34.4)
  BOTTOM w0.076: SH1803.1 83.02,34.42 v10(83.03,34.4)
DVDD_PROC_B_PMIC_GND: length 34.8
  TOP w0.076: v8(104.78,38.19) 104.91,38.19 105.05,38.05 U2001.D7
  IN2 w0.076: v3(104.2,37.8) 104.23,37.77 104.36,37.77 v8(104.78,38.19)
  IN4 w0.076: v4(104.32,37.42) 104.32,37.45 104.2,37.57 v3(104.2,37.8)
  IN5 w0.076: v4(104.32,37.42) 104.17,37.27 104.17,37.08 103.89,36.8 103.89,36.03 104.07,35.85 104.07,32.01 101.69,29.63 84.59,29.63 83.42,30.8 82.41,30.8 82.12,31.09 82.12,31.96 82.79,32.62 82.79,34.32 v10(82.7,34.4)
  BOTTOM w0.076: SH1804.2 82.7,34.57 v10(82.7,34.4)
DVDD_PROC_L: length 3.8
  TOP w0.2: 84.22,36.76 v7(84.64,36.76) v8(84.64,37.16) 84.64,37.19 84.27,37.56 v8(84.24,37.56) v8(83.83,37.56) v8(83.43,37.56) U1001.U7 ; 84.22,36.76 84.21,36.76 ; 84.22,36.76 v8(84.21,36.77) 84.21,36.76 ; v7(83.83,36.76) 84.21,36.76
  IN1 w0.22: v8(84.24,37.56) v8(83.83,37.56) v8(83.43,37.56)
  vias: v1(98.51,40.42) v1(98.51,40.17) v1(98.8,40.4) v1(98.8,40.15) v1(99.03,39.08) v1(99.02,38.82) v1(99.1,40.4) v1(99.1,40.15) v1(99.3,39.08) v1(99.27,38.82) v1(99.38,40.4) v1(99.41,40.15) v1(99.53,38.82) v1(99.55,39.08) v1(99.69,40.4) v1(99.69,40.15) v1(99.86,39.08) v1(99.86,38.82) v1(100.11,39.08) v1(100.11,38.82) v2(98.51,40.42) v2(98.51,40.17) v2(98.8,40.4) v2(98.8,40.15) v2(99.03,39.08) v2(99.02,38.82) v2(99.1,40.4) v2(99.1,40.15) v2(99.3,39.08) v2(99.27,38.82) v2(99.38,40.4) v2(99.41,40.15) v2(99.53,38.82) v2(99.55,39.08) v2(99.69,40.4) v2(99.69,40.15) v2(99.86,39.08) v2(99.86,38.82) v2(100.11,39.08) v2(100.11,38.82) v3(83.34,37.89) v3(83.79,37.9) v3(83.89,37.08) v3(84.3,37.23) v3(84.57,37.6) v3(98.62,39.82) v3(98.65,39.41) v3(99.1,39.82) v3(99.13,39.41) v3(99.61,39.82) v3(99.61,39.41) v4(97.6,40.78) v4(97.6,40.48) v4(97.6,40.2) v4(97.65,39.93) v4(97.65,39.68) v4(97.58,39.44) v4(97.6,39.17) v4(97.73,38.93) v4(97.87,40.8) v4(97.87,40.47) v4(97.87,40.21) v4(97.94,39.97) v4(97.93,39.71) v4(97.91,39.44) v4(97.91,39.16) v4(97.94,38.78) v4(98.13,40.8) v4(98.13,40.47) v4(98.13,40.21) v4(98.24,39.97) v4(98.23,39.71) v4(98.19,39.44) v4(98.19,39.16) v4(98.2,38.77) v4(98.38,40.8) v4(98.38,40.49) v4(98.38,40.19) v4(98.43,39.1) v4(98.46,38.77) v4(98.64,40.8) v4(98.64,40.49) v4(98.64,40.19) v4(98.69,39.07) v4(98.71,38.77) v4(98.89,40.8) v4(98.89,40.49) v4(98.89,40.19) v5(81.29,42.25) v5(81.29,42) v5(81.29,40.98) v5(81.29,40.73) v5(81.27,39.71) v5(81.27,39.46) v5(81.54,42.25) v5(81.54,42) v5(81.54,40.98) v5(81.54,40.73) v5(81.53,39.71) v5(81.53,39.46) v5(82.29,40.27) v5(82.29,40.02) v5(82.54,40.27) v5(82.54,40.02) v9(83.36,37.57) v9(83.59,38.21) v9(83.59,37.61) v9(83.91,38.2) v9(83.92,37.5) v9(84.22,37.91) v9(84.18,37.61) v9(84.45,37.95) v9(84.94,37.57) v10(82.86,38.05) v10(83.03,38.27) v10(82.95,37.75) v10(83.21,37.92) v10(83.31,38.3) v10(83.36,37.57) v10(83.52,37.93) v10(83.59,38.21) v10(83.59,37.61) v10(83.84,37.87) v10(83.91,38.2) v10(83.92,37.5) v10(84.25,38.21) v10(84.22,37.91) v10(84.18,37.61) v10(84.45,37.95) v10(84.47,37.58) v10(84.57,38.19) v10(84.65,37.83) v10(84.69,37.54) v10(84.85,38.14) v10(84.91,37.83) v10(84.94,37.57)
DVDD_PROC_L_PMIC_FB: length 43.4
  TOP w0.076: U2001.E9 v8(105.62,39.25)
  IN2 w0.076: v3(104.25,39.15) 104.25,39.13 104.66,38.72 105.1,38.72 v8(105.62,39.25)
  IN4 w0.076: v4(104.25,38.79) 104.25,39.12 104.25,39.13 v3(104.25,39.15)
  IN5 w0.076: v10(82.33,37.56) 82.31,37.59 82.03,37.59 81.6,37.15 81.6,30.91 82.17,30.33 83.22,30.33 84.39,29.17 102.01,29.17 105.37,32.52 105.37,38.41 104.83,38.94 104.53,38.94 104.38,38.79 v4(104.25,38.79)
  BOTTOM w0.089: v10(82.33,37.56) 82.49,37.4 82.64,37.4 SH1807.1
DVDD_PROC_L_PMIC_GND: length 40.3
  IN2 w0.076: v3(104.9,39.1) 105.07,39.1 v8(105.22,39.25)
  IN4 w0.076: v4(104.61,38.56) 104.61,38.74 104.85,38.98 104.85,39.07 104.88,39.1 v3(104.9,39.1)
  IN5 w0.076: v4(104.61,38.56) 104.63,38.56 104.67,38.6 104.96,38.6 105.21,38.35 105.21,32.58 101.95,29.32 84.45,29.32 83.29,30.48 82.24,30.48 81.75,30.97 81.75,37.09 81.97,37.31 v10(82.12,37.31)
  BOTTOM w0.089: SH1808.2 82.7,37.24 82.42,37.24 82.35,37.31 v10(82.12,37.31)
DVDD_SRAM_CORE: length 50.4
  TOP w0.15: U1001.Y15 85.95,36.07 85.95,35.85 86.13,35.66 86.13,35.46 U1001.AC14 ; U1001.Y15 85.96,36.64 85.95,36.64 v8(85.8,36.79) 85.69,36.9 85.69,36.91 U1001.T11 84.33,38.26 84.33,38.46 84.54,38.66 84.54,38.86 84.33,39.06 84.33,39.26 84.54,39.46 84.54,39.66 84.33,39.86 84.33,40.06 U1001.J12 ; U1001.Y15 86.54,36.06 86.73,36.06 86.94,36.26 87.13,36.26 87.34,36.06 87.54,36.06 87.73,36.26 87.94,36.26 88.13,36.06 88.33,36.06 88.51,36.24 88.51,36.48 88.33,36.66 88.33,36.86 v8(88.64,37.16)
  IN1 w0.2: v7(109.22,40.85) 109.81,40.85 109.92,40.96
  IN1 w0.406: 109.92,40.96 110.03,40.96 110.82,41.75 110.92,41.75 111.59,42.43 111.59,43.31 111.34,43.57 110.93,43.57
  IN2 w0.2: v3(86.22,37.06) 86.17,37.06 86.07,36.96 86,36.96 85.82,36.79 v8(85.8,36.79) ; v3(88.32,38.22) 88.35,38.2 88.35,37.81 88.58,37.57 88.58,37.21 v8(88.64,37.16)
  IN4 w0.203: v10(85.68,36.72) 85.83,36.87 85.98,36.87 86.17,37.06 v3(86.22,37.06)
  IN4 w0.406: v5(88.76,38.18) 88.42,38.18 88.37,38.22 v3(88.32,38.22)
  BOTTOM w0.406: v5(88.76,38.18) 88.76,38.18 89.55,38.18 89.7,38.34 90.06,38.34 91.2,39.48 92.09,39.48 96.27,43.67 96.27,44.68 96.4,44.8 C2146.1 96.91,45.19 96.25,45.85 96.25,47.38 97.12,48.25 104.73,48.25 105.54,47.43 105.54,44.49 105.77,44.26 109.75,44.26
  vias: v2(110.42,43.7) v2(110.57,43.45) v3(110.24,43.42) v4(110.14,44.08) v4(110.14,43.82) v5(110.14,44.08) v5(110.14,43.82)
DVDD_SRAM_PROC_B: length 5.1
  TOP w0.406: C2147.1 113.9,39.19 113.33,39.19 v6(113.19,39.33)
  IN1 w0.254: v7(109.22,40.05) 109.33,39.94 110.25,39.94 110.47,39.71
  IN1 w0.406: 110.47,39.71 110.76,39.42 112.89,39.42 112.99,39.33 v6(113.19,39.33)
  vias: v3(85.83,34.86) v3(85.83,34.35) v7(85.43,35.16) v8(85.43,35.16) v9(85.52,34.8) v9(85.59,34.56) v10(85.52,34.8) v10(85.59,34.56)
DVDD_SRAM_PROC_L: length 6.4
  IN1 w0.406: v2(110.19,40.5) 110.17,40.5 110.12,40.45 v7(109.62,40.45)
  IN2 w0.203: v8(83.03,36.76) 83.03,36.9 83.02,36.92 v3(83.02,37.15)
  IN2 w0.406: v3(110.52,40.5) v2(110.19,40.5)
  IN4 w0.203: v10(82.33,36.79) 82.42,36.79 82.71,37.07 82.94,37.07 v3(83.02,37.15)
  IN4 w0.406: v3(110.52,40.5) 111.44,40.5 112.02,41.08 112.02,41.66 112.66,42.3 112.96,42.3 113.44,42.79
  vias: v1(79.61,27.95) v1(79.87,27.95) v2(79.61,27.95) v2(79.87,27.95) v3(79.74,28.28) v4(78.57,57.67) v4(78.6,57.34) v4(78.77,57.52) v4(79,57.67) v4(78.98,57.37) v4(79.41,28.33) v4(79.54,28.56) v4(79.79,28.61) v4(80.02,28.48) v5(79.41,28.33) v5(79.54,28.56) v5(79.79,28.61) v5(80.02,28.48)
DVDD_VSRAM_GPU_PMU: length 38.2
  IN2 w0.3: v8(87.43,37.96) 87.43,38.3 v3(87.44,38.3)
  IN2 w0.406: v3(112.01,44.85) 112.01,44.75 112.71,44.05 112.84,44.05 113.34,43.55 113.34,42.76 112.94,42.35 112.73,42.35 112.02,41.64 112.02,41.23 v2(111.95,41.15)
  BOTTOM w0.406: C1820.1 88.46,38.69 89.33,38.69 89.49,38.85 89.91,38.85 91.1,40.04 91.86,40.04 95.69,43.87 95.69,47.61 96.89,48.81 105.12,48.81 105.58,48.35 110.7,48.35 111.74,47.31 111.74,45.36 111.75,45.35
  vias: v1(111.95,40.9) v2(111.95,40.9) v4(111.31,44.92) v4(111.6,45.24) v5(111.31,44.92) v5(111.6,45.24) v9(87.13,38.21) v9(87.87,38.26) v10(87.13,38.21) v10(87.87,38.26)
DVSS18_IO: length 6.2
  IN2 w0.058: v8(108.02,38.45) 108.09,38.45 108.29,38.65 108.59,38.65 108.63,38.61 108.87,38.61 109.06,38.41 109.26,38.41 109.53,38.14 109.53,37.62 109.65,37.51 110.04,37.51 110.23,37.33 110.23,36.05 110.47,35.81 v3(110.62,35.81)
  IN4 w0.058: v3(110.62,35.81) 110.62,35.87 110.68,35.93 v5(111.08,35.93)
  BOTTOM w0.089: v5(111.08,35.93) C2139.2
GND_SMPS: length 1.8
  TOP w0.089: U2001.E1 105.6,35.65 104.98,35.03 C2001.2 105.01,34.53 SH2001.1
GND_VCORE: length 0.8
  TOP w0.2: v7(104.02,40.45) U2001.B13 v7(104.42,40.45)
  IN1 w0.254: v7(104.42,40.45) v7(104.02,40.45)
  vias: v1(104.25,42.98) v1(104.28,42.73) v1(104.55,42.93) v1(104.55,42.68) v2(104.25,42.98) v2(104.28,42.73) v2(104.55,42.93) v2(104.55,42.68)
GND_VDRAM1:
  vias: v1(106.84,42.65) v1(106.83,41.25) v1(106.87,43.16) v1(106.87,42.91) v2(106.84,42.65) v2(106.87,43.16) v2(106.87,42.91)
GND_VGPU: length 0.8
  TOP w0.2: v7(105.22,40.45) v7(105.22,40.05)
  IN1 w0.254: v7(105.22,40.05) v7(105.22,40.45)
  vias: v1(101.91,40.18) v1(101.91,39.92) v1(102.17,40.18) v1(102.17,39.92) v2(101.91,40.18) v2(101.91,39.92) v2(102.17,40.18) v2(102.17,39.92)
GND_VMODEM: length 1.1
  TOP w0.254: U2001.G15 U2001.G16 106.42,42.37
  vias: v1(105.8,42.99) v1(105.77,42.74) v1(106.03,42.75) v2(105.68,44.78) v2(105.79,45.02) v2(105.95,44.7)
GND_VPA: length 2.7
  IN1 w0.254: v7(104.42,36.85) 104.3,36.97 104.05,36.97
  IN1 w0.508: 102.04,36.39 102.13,36.48 103.35,36.48 103.84,36.97 104.05,36.97
  vias: v1(101.96,36.75) v1(101.96,36.49) v1(102.21,36.75) v1(102.21,36.49) v2(101.96,36.75) v2(101.96,36.49) v2(102.21,36.75) v2(102.21,36.49)
GND_VPROC11: length 1.9
  TOP w0.2: v8(104.02,38.45) U2001.B8 v8(104.42,38.45)
  IN1 w0.991: 103.75,37.94 102.26,37.94
  vias: v1(101.93,37.45) v1(101.93,37.19) v1(102.19,37.45) v1(102.19,37.19) v2(101.93,37.45) v2(101.93,37.19) v2(102.19,37.45) v2(102.19,37.19)
GND_VPROC12: length 2.7
  IN1 w0.254: v7(105.22,38.45) v7(105.22,38.85)
  IN1 w0.737: 102.26,38.95 103.39,38.95 103.52,39.09 104.52,39.09
  vias: v1(101.95,39.47) v1(101.95,39.21) v1(102.2,39.47) v1(102.2,39.21) v2(101.95,39.47) v2(101.95,39.21) v2(102.2,39.47) v2(102.2,39.21)
GND_VREF: length 1.7
  IN2 w0.254: v8(108.82,40.45) 108.85,40.48 v3(109.2,40.48)
  IN4 w0.254: v3(109.2,40.48) v5(109.61,40.48)
  BOTTOM w0.254: v5(109.61,40.48) 110.48,40.48
GND_VS1: length 1.9
  IN1 w1: 103.66,35.52 103.41,35.28 103.41,34.22 ; 103.69,35.52 104.06,35.9
  vias: v1(103.89,33.62) v1(103.89,33.36) v1(104.15,33.62) v1(104.15,33.36) v2(103.89,33.62) v2(103.89,33.36) v2(104.15,33.62) v2(104.15,33.36) v7(104.02,36.45) v7(104.42,36.45) v8(104.02,36.45) v8(104.42,36.45)
GND_VS2: length 3.3
  IN1 w0.254: v7(108.02,40.85) 108.02,41.1 108.25,41.33
  IN1 w0.508: 108.42,43.68 108.75,43.34 108.75,42.57 108.25,42.06 108.25,41.33
  vias: v1(108.24,43.85) v1(108.24,43.6) v1(108.42,44.06) v2(108.24,43.85) v2(108.24,43.6) v2(108.42,44.06)
VBAT_IN_N: length 88.5
  IN2 w0.076: v2(9.76,13.65) 9.99,13.65 10.07,13.57 10.07,12.92 10.44,12.55 11.23,12.55 v3(11.49,12.3)
  IN3 w0.076: v3(65.06,6.03) 64.8,5.77 64.8,5.61 64.59,5.39 62.56,5.39 61.57,4.4 54.43,4.4 54,3.97 35.52,3.97 29.95,9.53 26.87,9.53 26.56,9.23 16.46,9.23 13.13,12.55 11.74,12.55 v3(11.49,12.3)
  IN4 w0.076: v5(65.01,6.36) 65.01,6.05 65.03,6.03 v3(65.06,6.03)
  BOTTOM w0.076: NC288.1 87.97,12.25 80.04,12.25 73.59,5.8 64.89,5.8 64.8,5.89 64.8,6.15 v5(65.01,6.36)
VBAT_IN_P: length 88.2
  IN2 w0.076: v2(10.52,13.65) 10.3,13.65 10.22,13.57 10.22,12.99 10.5,12.71 11.26,12.71 v3(11.46,12.91)
  IN3 w0.076: v3(11.46,12.91) 11.67,12.71 13.19,12.71 16.52,9.38 26.5,9.38 26.81,9.68 30.02,9.68 35.58,4.12 53.93,4.12 54.36,4.55 61.5,4.55 62.49,5.54 64.52,5.54 64.65,5.67 64.65,5.75 v3(64.4,6)
  IN4 w0.076: v3(64.4,6) 64.42,6 64.45,6.03 v5(64.45,6.36)
  BOTTOM w0.076: NC287.1 87.97,12.1 80.11,12.1 73.66,5.64 64.83,5.64 64.65,5.82 64.65,6.15 v5(64.45,6.36)
227E_DET_TRIGGER_L: length 16
  TOP w0.089: v2(12.43,24.52) 11.87,25.08 U6541.B1
  IN2 w0.058: v2(12.43,24.52) 11.84,23.93 10.4,23.93 7.73,26.6 7.73,33.69 8.62,34.58 v2(8.62,35.3)
227E_RING2: length 2.2
  TOP w0.203: 12.3,26.17 12.05,26.17 U6541.D1
  TOP w0.508: R90759.1 12.93,26.17 12.3,26.17
227E_RING2_SENSE: length 1.9
  TOP w0.254: U6541.C4 10.5,25.53 9.39,25.53 R90761.1
227E_SLEEVE: length 5.8
  TOP w0.203: v1(10.27,26.55) 10.4,26.42 10.78,26.42 10.96,26.24 U6541.D3
  IN1 w0.508: v1(10.27,26.55) 9.66,26.55 8.54,27.67 7.88,27.67 7.35,28.2 v1(7.35,29.22)
227E_SLEEVE_SENSE: length 5
  TOP w0.254: v1(9.61,25.94) 10.5,25.94 U6541.D4 ; R90762.1 7.31,27.78 v1(7.09,27.57)
  IN1 w0.254: v1(7.09,27.57) 7.09,27.44 7.98,26.55 8.9,26.55 9.51,25.94 v1(9.61,25.94)
227E_TIP: length 2.2
  TOP w0.203: 12.3,25.48 U6541.C1
  TOP w0.508: 12.3,25.48 12.6,25.48 R90764.1
ACCDET: length 24.2
  TOP w0.089: U2001.K6 107.62,38.03 v8(107.69,38.09)
  IN2 w0.058: v3(107.32,41.9) 107.14,41.71 107.14,40.4 107.41,40.13 107.41,39.96 107.46,39.91 107.46,39.64 107.02,39.19 107.02,38.37 107.1,38.29 107.35,38.29 107.55,38.09 v8(107.69,38.09)
  IN4 w0.058: v4(106.91,42.66) 106.91,42.31 v3(107.32,41.9)
  IN5 w0.076: v4(106.91,42.66) 106.91,42.56 105.33,40.98 105.33,39.21 105.75,38.79 105.75,35.68 106.03,35.4 106.03,35.11 105.75,34.83 105.75,29.04 v5(104.3,27.59)
  BOTTOM w0.089: v5(104.3,27.59) 104.3,26.79 R6225.1
ACCEL_INT_AP_ODL: length 86.2
  TOP w0.089: R90569.1 140.57,35.19 v1(140.32,34.93)
  IN1 w0.076: v1(140.32,34.93) 140.42,34.83 140.42,30.33 140.32,30.23 140.32,26.11 140.14,25.93 140.14,23.25 139.2,22.31 135.12,22.31 132.93,20.12 v2(131.3,20.12)
  IN2 w0.06: v8(89.04,37.96) 89.24,38.16 89.53,38.16 89.93,38.56 89.93,38.86 90.21,39.14 93.16,39.14 93.23,39.07
  IN2 w0.075: v2(131.3,20.12) 131.14,20.12 130.92,20.34 130.92,22.51 130.41,23.02 124.8,23.02 124.19,23.63 122.41,23.63 120.02,26.02 118.4,26.02 117.72,26.69 115.98,26.69 115.7,26.96 111.62,26.96 110.9,26.24 109.42,26.24 108.97,25.78 107.75,25.78 107.65,25.68 105.62,25.68 104.2,24.26 103.01,24.26 102.68,23.93 100.21,23.93 99.14,25 99.14,25.59 98.22,26.52 98.22,27.6 97.7,28.12 97.7,29.16 97,29.86 97,31.55 96.91,31.64 96.91,34.66 96.29,35.28 94.69,35.28 93.73,36.24 93.73,36.88 94.43,37.57 94.43,38.18 94.19,38.42 94.19,38.64 93.88,38.96 93.34,38.96 93.23,39.07
ACOK_OD: length 139.5
  TOP w0.089: R91186.1 51.78,18.71 51.78,18.61 52.48,17.91 v2(52.87,17.91) U124.A6 ; R91175.2 126.93,54.15 127.22,54.44 129.72,54.44 130.34,55.06 130.65,55.06 131.35,54.36 132.06,54.36 132.71,53.71 132.71,51.03 132.55,50.87 132.55,50.18 134.73,48 134.73,43.72 133.89,42.88 126.96,42.88 125.26,41.18 v1(124.11,41.18)
  IN1 w0.076: v1(124.11,41.18) 123.4,41.18 122.49,40.27 122.49,36.34 122.41,36.27 v2(121.99,36.27)
  IN2 w0.058: v3(52.56,18.14) 52.61,18.14 52.85,17.91 v2(52.87,17.91) ; v3(121.99,35.94) v2(121.99,36.27)
  IN3 w0.102: v3(52.56,18.14) 52.61,18.09 52.61,17.94 53.09,17.46 53.91,17.46 54.92,18.47 57.29,18.47 58.43,17.33 59.6,17.33 60.26,16.67 60.53,16.67 60.68,16.52 61.88,16.52 61.98,16.41 61.98,13.95 65.06,10.88 69.01,10.88 69.98,11.85 86.3,11.85 87.46,10.69 89.4,10.69 91.64,8.45 114.03,8.45 114.89,9.31 114.89,10.32 115.76,11.18 116.15,11.18 120.2,15.23 120.2,17.63 121.19,18.62 121.19,18.64 121.19,18.65 121.19,26.71 121.2,26.71 121.2,27.39 121.19,27.39 121.19,27.56 120.61,28.15 120.61,33.84 121.99,35.22 v3(121.99,35.94)
ALS_RGB_INT_ODL: length 34
  TOP w0.089: R91209.1 122.95,46.46 123.1,46.31 123.66,46.31 123.78,46.18 123.78,44.99 124.16,44.61 v1(124.16,43.9) ; U6574.5 150.35,37.34 150.48,37.47 150.48,38.49 150.17,38.79 140.44,38.79 136.94,42.3 v1(127.26,42.3)
  IN1 w0.076: v1(124.16,43.9) 125.79,43.9 127.26,42.42 v1(127.26,42.3)
AMP_L_GAIN: length 4.3
  TOP w0.089: R90706.1 v1(21.72,5.44)
  IN1 w0.076: v1(21.72,5.44) 22.05,5.77 22.79,5.77 23.17,5.39 v7(24.64,5.39)
AMP_R_EN: length 2.3
  TOP w0.254: U6502.A1 33.52,10.25 34.18,10.91 R90268.2
AMP_R_GAIN: length 4.2
  TOP w0.203: R90265.1 34.4,9.38 34.26,9.51 v1(34.26,9.77)
  IN1 w0.203: v7(31.86,10.65) 31.86,10.32 32.41,9.77 v1(34.26,9.77)
AMP_R_POWER: length 5.5
  TOP w0.254: U6502.A2 31.86,9.86 32.27,9.45 C9020.1 33.04,8.23 33.18,8.09 C9021.2 33.86,8.09 34.1,7.85 R90265.2 35.36,7.85 R90530.2
ANX7625_HPD: length 14.8
  TOP w0.089: Q791.3 56.62,39.5 56.22,39.91 v1(55.99,39.91)
  IN1 w0.076: v2(64.97,44.19) 64.97,43.71 v1(65.26,43.42) ; v2(61.2,44.63) 60.69,44.13 59.73,44.13 59.19,43.59 59.19,43.08 57.93,41.81 57.24,41.81 56.47,41.05 56.47,40.4 v1(55.99,39.91)
  IN2 w0.058: v2(61.2,44.63) 61.6,45.04 62.54,45.04 62.59,44.99 62.59,44.35 62.87,44.08 63.64,44.08 63.8,44.24 64.92,44.24 v2(64.97,44.19)
ANX7625_SCL: length 8.6
  IN1 w0.076: v2(63.97,44.96) 63.83,44.96 63.74,44.87 63.74,44.15 63.91,43.97 64.16,43.97 64.43,43.7 64.58,43.7 64.86,43.43 v1(64.86,43.42)
  IN2 w0.058: v3(65.69,45.45) 65.64,45.45 65.44,45.24 65.44,45.02 65.25,44.83 64.36,44.83 64.15,45.04 64.05,45.04 v2(63.97,44.96)
  IN4 w0.058: v3(65.69,45.45) 65.77,45.52 v5(65.77,45.77)
  BOTTOM w0.089: R91255.2 v5(65.77,45.77) 66.2,45.77 66.33,45.65 66.33,44.99 66.58,44.74 67.19,44.74 67.36,44.91 Q800.4
ANX7625_SDA: length 6.6
  IN1 w0.076: v1(64.46,43.42) 64.38,43.42 64.06,43.74 63.82,43.74 63.51,44.06 63.51,44.96 63.91,45.37 v2(63.97,45.37)
  IN2 w0.058: v2(63.97,45.37) 64.08,45.25 64.23,45.25 64.44,45.05 65.16,45.05 65.23,45.11 65.23,45.24 65.03,45.44 v3(65.03,45.45)
  IN4 w0.058: v5(65.03,45.8) v3(65.03,45.45)
  BOTTOM w0.089: R91256.2 v5(65.03,45.8) R91240.2 64.24,45.75 64.14,45.64 Q799.4
ANX7625_XTAL_IN: length 3.3
  TOP w0.089: Y3.3 64.97,37.76 64.1,38.63 R91239.2 64.32,38.92 64.55,38.69 C10672.1 R91259.2
ANX7625_XTAL_IN_R: length 3.8
  TOP w0.089: U6578.D1 64.78,40.94 64.78,40.11 65.26,39.63 66.15,39.63 66.4,39.38 R91258.2 R91259.1
ANX7625_XTAL_OUT: length 8.9
  TOP w0.089: R91257.2 62.6,35.77 Y3.1 63.86,37.04 63.86,38.38 R91239.1 63.25,39 C10671.1 62.57,39.22 62.72,39.38 63.74,39.38 64.46,40.1 U6578.C1
AP_CLK26M_S0: length 56.1
  TOP w0.089: v2(115.6,34.14) 115.94,34.48 115.94,35.03 115.85,35.12 115.07,35.12 114.97,35.22 C8001.1 R8001.2
  IN2 w0.058: v3(95.26,28.89) 95.63,28.89 95.75,28.76 95.75,26.93 96.51,26.17 96.51,25.76 96.93,25.34 96.93,24.32 v3(97.21,24.03) ; v8(87.03,34.36) 87.11,34.36 87.44,34.04 87.44,33.08 87.87,32.64 87.87,31.22 86.83,30.18 86.83,29.87 85.53,28.57 85.53,26.2 85.25,25.92 85.25,25.91 v3(85.27,25.89) ; v2(115.6,34.14) 115.6,33.83 v3(115.55,33.79)
  IN3 w0.102: v3(95.26,28.89) 95.26,28.11 94.13,26.98 90.18,26.98 88.89,25.69 85.64,25.69 85.43,25.89 v3(85.27,25.89) ; v3(115.55,33.79) 115.38,33.61 115.38,30.96 114.74,30.33 113.6,30.33 113.14,29.88 113.14,29.83 112.48,29.17 109.11,29.17 108.77,28.84 107.07,28.84 106.69,29.22 105.04,29.22 104.73,28.91 103.34,28.91 102.83,28.4 101.96,28.4 101.56,28 101.56,26.88 101.08,26.41 99.37,26.41 97.21,24.25 v3(97.21,24.03)
AP_CTS_BT_RTS: length 130.1
  IN1 w0.06: v7(90.24,33.53) 90.22,33.53 90.05,33.36 89.86,33.36 89.7,33.2 89.7,33.03 89.82,32.91 89.82,32.52 89.87,32.47 89.87,32.44
  IN1 w0.076: 89.87,32.44 89.87,30.58 90.23,30.22 90.23,28.95 91,28.18 91,27.5 90.48,26.99 90.48,25.93 91.07,25.35 91.07,25.15 91.68,24.54 v1(91.93,24.54) 92.07,24.4 92.07,24.31 92.77,23.61 92.77,22.59 93.86,21.49 94.89,21.49 v2(95.03,21.63)
  IN2 w0.058: v3(139.66,59.99) 139.25,59.81 139.17,59.83 139.13,59.93 139.01,60.05 138.32,60.05 138.12,59.85 138.12,59.12 135.64,56.65 135.64,48.34 137.56,46.42 138.17,46.42 143.71,40.89 143.71,30.31 145.15,28.86 145.15,26.83 143.58,25.25 143.58,22.43 143.33,22.18 143.33,20.96 142.66,20.3 142.66,19.02 141.78,18.13 139.06,18.13 137.64,19.55 135.7,19.55 133.77,17.63 133.77,17.01 133.28,16.52 125.8,16.52 125.28,16 124.81,16 122.7,13.89 119.52,13.89 118.18,12.55 117.06,12.55 116.49,11.98 115.49,11.98 115.24,12.23 113.92,12.23 113.15,13 103.35,13 103.12,12.77 102.35,12.77 102.12,13 99.76,13 99.16,13.6 94.26,13.6 92.26,15.59 92.26,18.79 94.19,20.72 95.31,20.72 95.49,20.9 95.49,21.32 95.35,21.46 95.21,21.46 v2(95.03,21.63)
  IN4 w0.058: v3(139.66,59.99) v5(139.89,59.76)
AP_EC_WATCHDOG_L: length 51.3
  TOP w0.089: v2(99.91,48.04) 100.48,47.46 R90453.1 ; U6517.B5 125.34,48.77 125.59,48.52 125.59,47 R90906.2 125.2,46.84 125.15,46.89 v2(125.15,47.15)
  IN2 w0.058: v8(89.44,39.56) 89.6,39.56 89.82,39.78 91.25,39.78 91.81,40.34 92.18,40.34 92.44,40.09 94.22,40.09 94.6,40.47 95.06,40.47 95.53,40.94 95.63,40.94 95.98,41.29 96.46,41.29 96.67,41.51 96.67,43.41 96.96,43.69 97.19,43.69 97.44,43.95 97.44,44.35 98.06,44.97 98.06,45.73 98.59,46.25 98.59,46.72 v2(99.91,48.04) 100.82,48.95 103.26,48.95 103.41,49.1 103.41,51.23 104.31,52.13 113.11,52.13 113.86,51.37 114.48,51.37 115.04,50.81 115.04,50.5 116.21,49.33 116.21,48.86 118.03,47.05 122.26,47.05 122.61,47.4 124.72,47.4 124.98,47.15 v2(125.15,47.15)
AP_FLASH_WP_ODL: length 98.2
  TOP w0.089: v2(46.44,30.13) 46.31,30.01 46.31,25.91 45.56,25.16 R90611.2
  IN1 w0.06: 93.71,38.08 93.71,38.3 93.09,38.92 91.18,38.92 91.09,38.83 90.75,38.83 90.29,38.36 v7(90.24,38.36)
  IN1 w0.076: 93.71,38.08 93.71,37.17 93.79,37.09 93.79,35.92 93.99,35.72 93.99,34.7 94.27,34.41 94.27,33.38 95.16,32.49 95.16,30.53 99.93,25.76 v2(100.31,25.76)
  IN2 w0.058: v2(46.44,30.13) 46.71,30.13 v3(46.79,30.22) ; v3(100.37,25.38) 100.37,25.46 100.31,25.52 v2(100.31,25.76)
  IN3 w0.102: v3(100.37,25.38) 100.36,25.37 100.36,24.71 97.8,22.15 92.16,22.15 91,20.98 87.66,20.98 86.74,20.07 78.45,20.07 71.1,27.41 71.1,28.16 70.09,29.17 70.09,29.45 69.05,30.49 68.18,30.49 67.12,31.55 67.12,34.04 66.02,35.13 61.63,35.13 60.18,33.69 60.18,28.31 58.82,26.96 49.64,26.96 46.85,29.74 46.85,30.16 v3(46.79,30.22)
AP_H1_I2C_SCL: length 4.5
  TOP w0.089: R90973.1 R90434.1 57.76,20.69 57.65,20.69 56.73,19.77 56.73,19.16 U124.H8
AP_H1_I2C_SDA: length 3.8
  TOP w0.089: R90410.1 54.88,21.77 R90974.1 54.59,21.45 v2(54.59,20)
  IN2 w0.058: v2(54.98,18.91) 54.67,19.22 54.67,19.92 v2(54.59,20)
AP_IN_SLEEP_L: length 4.2
  IN1 w0.076: v1(124.19,45.7) 124.52,46.03 124.52,48.55 125.34,49.37 v1(125.34,49.42)
AP_MSDC1_CLK: length 11.4
  TOP w0.089: v1(91.65,32.57) 91.55,32.47 91.55,31.88 91.78,31.65 91.78,31.4 91.25,30.87 91.25,27.91 91.36,27.79 91.88,27.79 92.49,27.18 R90340.1 R90696.1
  IN1 w0.06: 91.66,32.57 91.74,32.65 91.74,33.8 91.3,34.23 91.3,34.42 90.9,34.83 90.56,34.83 90.43,34.96 90.04,34.96 v7(89.84,35.16)
  IN1 w0.076: 91.66,32.57 v1(91.65,32.57)
AP_MSDC1_CMD: length 7.8
  TOP w0.075: 91.3,34.83 91.14,34.98 90.86,34.98 U1001.AD26
  TOP w0.089: R90697.1 R90341.1 92.74,29.55 92.62,29.67 92.62,30.92 92.76,31.06 92.76,32.59 92.43,32.92 92.43,33.15 91.98,33.6 91.98,33.92 91.45,34.45 91.45,34.68 91.3,34.83
AP_MSDC1_DAT0: length 7
  TOP w0.089: R90699.1 90.28,30.23 90.13,30.38 90.13,30.98 90.24,31.09 R90342.1 91.01,31.09 91.27,31.35 91.27,31.96 v1(91.22,32.01)
  IN1 w0.06: v7(89.84,34.76) 90.04,34.56 90.39,34.56 90.45,34.5 90.45,34.4 90.85,33.99 91.14,33.99 91.5,33.64 91.5,32.95 91.17,32.62
  IN1 w0.076: v1(91.22,32.01) 91.22,32.09 91.17,32.14 91.17,32.62
AP_MSDC1_DAT1: length 7
  TOP w0.075: 92.13,32.6 92.13,33 91.67,33.46 91.67,33.65 91.2,34.12 90.87,34.12 U1001.AE26
  TOP w0.089: R90698.1 91.68,28.86 91.58,28.96 R90343.1 91.58,29.7 91.52,29.75 91.52,30.77 92.22,31.46 92.22,32.51 92.13,32.6
AP_MSDC1_DAT2: length 9.3
  TOP w0.06: v8(89.37,35.06) 89.43,35.13 U1001.AC23
  TOP w0.089: R90701.1 88.07,28.07 R90591.1
  IN2 w0.058: v2(88.09,27.93) 88.12,27.95 88.46,27.95 89.06,28.56 89.06,28.66 89.56,29.16 89.56,31.93 89.71,32.07 89.71,32.31 89.42,32.59 89.19,32.59 89.07,32.71 89.07,34.47 89.44,34.83 89.44,35 89.38,35.06 v8(89.37,35.06)
AP_MSDC1_DAT3: length 5
  TOP w0.075: 91.04,34.76 U1001.AD27
  TOP w0.089: 91.04,34.76 91.3,34.5 91.3,34.35 91.83,33.81 91.83,33.54 92.28,33.09 92.28,32.78 92.49,32.57 92.49,31.34 91.92,30.77 R90700.1
AP_RTS_BT_CTS: length 129.9
  IN1 w0.06: 89.7,32.44 89.7,32.85 89.58,32.96 89.58,33.25 89.83,33.5 v7(89.83,33.56)
  IN1 w0.076: 89.7,32.44 89.7,30.54 90.08,30.16 90.08,28.89 90.85,28.12 90.85,27.57 90.33,27.05 90.33,25.86 90.74,25.46 v1(90.74,25.23) 90.77,25.23 91.79,24.21 91.96,24.21 92.62,23.55 92.62,22.52 93.8,21.34 94.85,21.34 v2(95,21.19)
  IN2 w0.058: v3(138.63,59.53) 139.04,59.71 139.07,59.79 139.03,59.86 138.97,59.93 138.37,59.93 138.24,59.8 138.24,59.07 135.76,56.6 135.76,48.39 137.61,46.54 138.22,46.54 143.82,40.94 143.82,30.36 145.27,28.91 145.27,26.78 143.7,25.2 143.7,22.38 143.44,22.13 143.44,20.91 142.78,20.25 142.78,18.97 141.83,18.01 139.01,18.01 137.59,19.44 135.75,19.44 133.89,17.58 133.89,16.96 133.33,16.4 125.85,16.4 125.33,15.88 124.86,15.88 122.75,13.77 119.56,13.77 118.23,12.43 117.11,12.43 116.53,11.86 115.44,11.86 115.19,12.12 113.87,12.12 113.1,12.88 103.4,12.88 103.17,12.65 102.31,12.65 102.08,12.88 99.71,12.88 99.11,13.48 94.21,13.48 92.14,15.54 92.14,18.84 94.14,20.83 95.26,20.83 95.37,20.95 95.37,21.27 95.3,21.34 95.16,21.34 v2(95,21.19)
  IN4 w0.058: v3(138.63,59.53) v5(138.39,59.76)
AP_RXD1_BT_TXD: length 92.5
  TOP w0.089: TP9066.1 76.97,43.72 77.56,43.72 77.65,43.63 v2(77.65,43.59)
  IN1 w0.06: v7(81.43,41.16) 81.32,41.16 80.91,41.58
  IN1 w0.076: v2(77.65,43.59) 77.81,43.42 77.81,43.35 78.13,43.03 79.45,43.03 80.71,41.78 80.73,41.78 80.79,41.72 80.79,41.69 80.91,41.58
  IN2 w0.058: v2(77.65,43.59) 77.81,43.75 77.81,43.83 77.16,44.48 77.16,44.74 76.28,45.61 76.28,59.29 79.81,62.82 94.24,62.82 94.6,63.18 116.1,63.18 118.04,61.24 119.97,61.24 120.2,61.46 121.7,61.46 122.23,60.93 123.38,60.93 123.78,61.34 124.53,61.34 125.57,62.37 127.99,62.37 128.6,61.76 129.16,61.76 129.4,61.52 129.4,61.07 v3(129.65,60.81)
  IN3 w0.102: v3(138.82,61.35) 139.04,61.56 139.04,61.75 138.86,61.93 130.01,61.93 129.42,61.34 129.42,61.07 129.65,60.84 v3(129.65,60.81)
  IN4 w0.058: v3(138.82,61.35) v5(138.82,61.02)
  BOTTOM w0.089: U1007.55 138.89,60.17 139.05,60.34 139.05,60.79 v5(138.82,61.02)
AP_SKU_ID: length 11.2
  TOP w0.089: v1(86.42,26.78) 86.95,26.78 87.12,26.61 R90725.1 86.46,26.17 86.39,26.24 R90726.1
  IN1 w0.06: 87.63,32.39 87.63,33.26 87.43,33.46 v7(87.43,33.56) 87.21,33.56 v2(86.98,33.33)
  IN1 w0.076: 87.63,32.39 87.63,31.19 86.9,30.46 86.9,29.44 86.22,28.76 86.22,27.39 86.32,27.29 86.32,26.88 v1(86.42,26.78)
  IN2 w0.058: v2(86.98,33.33) 86.98,33.28 86.85,33.15 v3(86.85,33.03)
  IN4 w0.058: v5(87.08,33.28) 86.85,33.06 v3(86.85,33.03)
AP_SPI_FLASH_CLK: length 100.6
  IN1 w0.06: v7(89.04,35.96) 88.84,36.16 88.84,37.28 88.92,37.36 90.32,37.36 90.44,37.24 90.44,37.01 90.69,36.76 92.24,36.76 93,36
  IN1 w0.076: v2(93,35.62) 93,35.77 93,36
  IN2 w0.058: v2(46.31,14.36) 46.44,14.49 46.44,15.62 48.09,17.27 48.09,21.75 v3(48.28,21.94) ; v2(93,35.62) 93.12,35.62 93.32,35.43 93.32,35.22 93.56,34.98 94.04,34.98 94.39,34.63 95.92,34.63 96.16,34.38 96.16,32.86 95.95,32.65 95.95,30.52 96.26,30.21 96.26,29.63 97.04,28.86 97.04,27.85 97.56,27.33 97.56,26.24 98.44,25.36 98.44,24.15 99.35,23.25 101.76,23.25 v3(102.68,22.33)
  IN3 w0.102: v3(48.28,21.94) 48.31,21.94 48.65,22.28 48.97,22.28 50.08,23.39 50.08,23.74 50.91,24.57 54.63,24.57 55.2,24 55.2,23.26 56.33,22.13 56.63,22.13 56.94,21.82 60.2,21.82 61.6,23.23 61.6,24.77 62.49,25.66 69.69,25.66 77.52,17.83 85.04,17.83 85.67,17.2 88.29,17.2 89.39,18.31 91.93,18.31 93.23,19.61 98.95,19.61 100.23,20.88 101.25,20.88 102.68,22.31 v3(102.68,22.33)
AP_SPI_FLASH_CS_L: length 83.6
  IN1 w0.06: 92.08,32.59 92.08,33.79 91.55,34.32 91.55,34.52 91.01,35.06 91.01,35.21 90.66,35.56 v7(90.24,35.56)
  IN1 w0.076: v2(96.31,28.49) 96.31,28.52 95.77,29.06 93.3,29.06 92.36,30 92.36,30.79 92.69,31.12 92.69,31.98 92.08,32.59
  IN2 w0.058: v3(48.57,23.25) 48.57,23.26 48.63,23.32 v2(48.9,23.32) ; v2(96.31,28.49) 96.31,27.68 96.93,27.06 96.93,25.98 97.81,25.1 97.81,23.69 98.94,22.56 100.64,22.56 100.82,22.38 v3(100.82,22.33)
  IN3 w0.102: v3(48.57,23.25) 48.62,23.3 48.62,23.36 50.59,25.33 54.95,25.33 55.96,24.31 55.96,23.58 56.65,22.89 57.01,22.89 57.31,22.59 59.89,22.59 60.84,23.54 60.84,25.09 62.17,26.42 70.01,26.42 77.84,18.59 85.35,18.59 85.98,17.96 87.97,17.96 89.08,19.07 91.62,19.07 92.92,20.37 98.63,20.37 99.91,21.65 100.36,21.65 100.82,22.1 v3(100.82,22.33)
AP_SPI_FLASH_MISO: length 87.6
  IN2 w0.058: v3(47.38,23.02) 47.48,23.12 v2(47.48,23.35) ; v8(89.04,36.76) 89.5,36.76 89.64,36.63 89.96,36.63 91.32,35.26 91.96,35.26 92.22,35 92.92,35 93.37,34.55 93.86,34.55 94.35,34.06 94.35,33.43 95.46,32.31 95.46,30.36 95.82,30 95.82,29.42 96.62,28.62 96.62,27.67 97.14,27.15 97.14,26.07 98.02,25.19 98.02,23.81 99.04,22.79 101.13,22.79 101.43,22.49 v3(101.43,22.33)
  IN3 w0.102: v3(101.43,22.33) 101.43,22.08 100.74,21.39 100.01,21.39 98.74,20.12 93.02,20.12 91.72,18.82 89.18,18.82 88.08,17.71 85.88,17.71 85.25,18.34 77.73,18.34 69.9,26.17 62.28,26.17 61.1,24.99 61.1,23.44 59.99,22.33 57.19,22.33 56.89,22.64 56.54,22.64 55.71,23.47 55.71,24.21 54.84,25.08 50.7,25.08 49.58,23.95 49.58,23.6 48.76,22.79 48.38,22.79 48.13,23.04 47.4,23.04 v3(47.38,23.02)
AP_SPI_FLASH_MOSI: length 99.2
  IN1 w0.06: v7(89.04,36.36) 89.24,36.56 89.24,36.92 89.28,36.96 90.32,36.96 90.64,36.64 92.19,36.64 92.75,36.08 92.75,35.95
  IN1 w0.076: v2(93,35.21) 92.75,35.46 92.75,35.95
  IN2 w0.058: v2(45.04,14.36) 45.7,14.36 46.21,14.87 46.21,15.72 47.86,17.37 47.86,22.1 47.96,22.21 v3(47.96,22.46) ; v2(93,35.21) 93.02,35.21 93.46,34.77 93.95,34.77 94.3,34.42 95.49,34.42 95.94,33.97 95.94,32.95 95.74,32.75 95.74,30.44 96.04,30.14 96.04,29.56 96.83,28.76 96.83,27.76 97.35,27.24 97.35,26.16 98.23,25.28 98.23,23.98 99.2,23.02 101.35,23.02 v3(102.04,22.33)
  IN3 w0.102: v3(47.96,22.46) 48.04,22.54 48.87,22.54 49.83,23.5 49.83,23.85 50.8,24.82 54.74,24.82 55.46,24.1 55.46,23.37 56.44,22.38 56.76,22.38 57.07,22.08 60.1,22.08 61.35,23.33 61.35,24.88 62.38,25.91 69.8,25.91 77.63,18.08 85.14,18.08 85.77,17.46 88.18,17.46 89.29,18.56 91.83,18.56 93.13,19.86 98.84,19.86 100.12,21.14 101,21.14 102.04,22.18 v3(102.04,22.33)
AP_SPI_H1_CLK: length 36.8
  TOP w0.089: U124.F9 55.98,19.41 55.98,20.29 56.03,20.34 R90415.1 R90976.2 56.03,22.78 56.27,23.02 56.7,23.02 56.83,23.15 58.1,23.15 58.28,23.32 v2(58.33,23.32)
  IN2 w0.058: v2(77.38,28.5) 77.15,28.5 76.56,29.09 75.42,29.09 74.45,30.06 74.45,31.33 72.54,33.24 71.1,33.24 69.95,34.38 67.84,34.38 66.91,33.45 66.19,33.45 65.74,33 v3(65.44,33) ; v2(58.33,23.32) 58.43,23.22 59.62,23.22 59.8,23.4 v3(59.8,23.65)
  IN3 w0.102: v3(59.8,23.65) 59.8,24.77 61.96,26.93 64.78,26.93 65.44,27.59 v3(65.44,33)
AP_SPI_H1_CS_L: length 38.5
  TOP w0.089: U124.J8 58.07,19.5 58.07,19.95 59.11,20.99 59.31,20.99 R90409.1 59.61,22.26 R90975.2 59.93,22.62 59.93,23.79 59.84,23.88 58.42,23.88 58.33,23.79 v2(58.33,23.73)
  IN2 w0.058: v3(64.12,33.46) 64.14,33.46 64.77,34.08 66.65,34.08 67.58,35.02 70.22,35.02 71.36,33.87 72.82,33.87 75.08,31.61 75.08,30.33 75.66,29.75 76.31,29.75 v2(76.69,30.13) ; v3(57.77,23.65) 57.87,23.76 58.3,23.76 v2(58.33,23.73)
  IN3 w0.102: v3(64.12,33.46) 64.12,33.43 64.07,33.38 64.07,32.24 64.17,32.14 64.17,28.05 63.81,27.69 61.65,27.69 57.77,23.81 v3(57.77,23.65)
AP_SPI_H1_MISO: length 4.9
  TOP w0.089: R91079.2 59.42,22.92 59.06,22.56 59.06,21.28 58.11,20.33 57.64,20.33 56.98,19.67 U124.H9
AP_SPI_H1_MOSI: length 41.2
  TOP w0.089: U124.C9 54.51,19.41 54.92,19.82 54.92,19.85 55.33,20.25 55.33,22.97 v2(55.86,23.5) ; R91080.2 79.46,30.01 79.31,30.16 79.05,30.16 78.85,30.36 78.19,30.36 v2(77.53,29.7)
  IN2 w0.058: v3(57.11,23.6) 57.06,23.6 56.8,23.35 55.99,23.35 55.86,23.48 v2(55.86,23.5) ; v2(77.53,29.7) 77.4,29.7 77.01,29.31 75.51,29.31 74.66,30.16 74.66,31.43 72.63,33.45 71.19,33.45 70.04,34.6 67.76,34.6 66.82,33.66 65.87,33.66 65.67,33.46 v3(65.03,33.46)
  IN3 w0.102: v3(57.11,23.6) 57.16,23.6 57.67,23.09 58.94,23.09 59.29,23.45 59.29,23.93 59.37,24.01 59.37,24.7 61.86,27.18 64.58,27.18 64.98,27.59 64.98,33.41 v3(65.03,33.46)
